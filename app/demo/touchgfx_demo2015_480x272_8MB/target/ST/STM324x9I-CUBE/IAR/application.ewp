# IAR project application.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429NI ST STM32F429NI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ST; STM32F429xx; USE_OS_SYSTICK
  ICCARM.CCIncludePath2: ..\..\..\..\generated\images\include; ..\..\..\..\generated\fonts\include; ..\..\..\..\generated\texts\include; ..\..\..\..\platform\os; ..\..\..\..\gui\include; ..\..\..\..\target\include; ..\..\..\..\..\..\..\touchgfx\framework\include; ..\..\..\..\..\..\..\touchgfx\framework\include\platform\core\arm\cortex-m\CMSIS; ..\..\..\..\..\..\..\touchgfx\framework\include\platform\hal\ST\mcu\stm32f4cube; ..\..\..\..\..\..\..\touchgfx\framework\include\platform\hal\ST\mcu\stm32f4cube\STM32F4xx_HAL_Driver; ..\..\..\..\..\..\..\touchgfx\framework\include\platform\hal\ST\mcu\stm32f4cube\CMSIS; ..\..\..\..\..\..\..\touchgfx\board\ST\STM324x9I-CUBE\include; ..\..\..\..\..\..\..\touchgfx\board\ST\STM324x9I-CUBE\include\bsp; ..\..\..\..\..\..\..\touchgfx\board\ST\STM324x9I-CUBE\source\vendor\STM324x9I_EVAL; ..\..\..\..\..\..\..\touchgfx\os\FreeRTOS7.6.0\Source\include; ..\..\..\..\..\..\..\touchgfx\os\FreeRTOS7.6.0\Source\portable\IAR\ARM_CM4F
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\..\..\..\platform\os; ..\..\..\..\..\framework\touchgfx\platform\core\arm\cortex-m\CMSIS\include; ..\..\..\..\..\framework\touchgfx\platform\hal\ST\board\STM32429I-EVAL1\include; ..\..\..\..\..\framework\touchgfx\platform\hal\ST\board\STM32429I-EVAL1\src; ..\..\..\..\..\framework\touchgfx\platform\hal\ST\mcu\stm32f4x9\inc; ..\..\..\..\..\framework\touchgfx\platform\os\FreeRTOS7.6.0\Source\include; ..\..\..\..\..\framework\touchgfx\platform\os\FreeRTOS7.6.0\Source\portable\IAR\ARM_CM4F
  OBJCOPY.OOCOutputFile: application-eval.srec
  ILINK.IlinkOutputFile: application.out
  ILINK.IlinkIcfFile: application.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\..\touchgfx\lib\core\cortex_m4f\IAR\touchgfx_core.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/generated/fonts
    ../../../../generated/fonts/src/: ApplicationFontProvider.cpp Font_Asap_Bold_otf_12_4bpp.cpp Font_Asap_Bold_otf_15_4bpp.cpp Font_Asap_Bold_otf_18_4bpp.cpp Font_Asap_Bold_otf_46_4bpp.cpp Font_Asap_Regular_11_4bpp.cpp Font_Asap_Regular_12_4bpp.cpp Font_Asap_Regular_15_4bpp.cpp Font_Asap_Regular_18_4bpp.cpp Font_ipaexg_12_4bpp.cpp Font_ipaexg_18_4bpp.cpp Font_NotoSans_Regular_12_4bpp.cpp Font_NotoSans_Regular_18_4bpp.cpp FontGetters.cpp Kerning_Asap_Bold_otf_12_4bpp.cpp Kerning_Asap_Bold_otf_15_4bpp.cpp Kerning_Asap_Bold_otf_18_4bpp.cpp Kerning_Asap_Bold_otf_46_4bpp.cpp Kerning_Asap_Regular_11_4bpp.cpp Kerning_Asap_Regular_12_4bpp.cpp Kerning_Asap_Regular_15_4bpp.cpp Kerning_Asap_Regular_18_4bpp.cpp Kerning_ipaexg_12_4bpp.cpp Kerning_ipaexg_18_4bpp.cpp Kerning_NotoSans_Regular_12_4bpp.cpp Kerning_NotoSans_Regular_18_4bpp.cpp Table_Asap_Bold_otf_12_4bpp.cpp Table_Asap_Bold_otf_15_4bpp.cpp Table_Asap_Bold_otf_18_4bpp.cpp Table_Asap_Bold_otf_46_4bpp.cpp Table_Asap_Regular_11_4bpp.cpp Table_Asap_Regular_12_4bpp.cpp Table_Asap_Regular_15_4bpp.cpp Table_Asap_Regular_18_4bpp.cpp Table_ipaexg_12_4bpp.cpp Table_ipaexg_18_4bpp.cpp Table_NotoSans_Regular_12_4bpp.cpp Table_NotoSans_Regular_18_4bpp.cpp
  group Application/generated/images
    ../../../../generated/images/src/: BitmapDatabase.cpp
  group Application/generated/images/CustomControls
    ../../../../generated/images/src/CustomControls/: control_center_button.cpp control_center_button_pressed.cpp control_color_wheel.cpp control_menu_arrow_down.cpp control_menu_arrow_down_inactive.cpp control_menu_arrow_down_pressed.cpp control_menu_arrow_up-inactive.cpp control_menu_arrow_up-pressed.cpp control_menu_arrow_up.cpp control_menu_button.cpp control_menu_button_pressed.cpp control_menu_icon_datepicker_large.cpp control_menu_icon_datepicker_small.cpp control_menu_icon_gauge_large.cpp control_menu_icon_gauge_small.cpp control_menu_icon_percentage_large.cpp control_menu_icon_percentage_small.cpp control_menu_icon_three_way_large.cpp control_menu_icon_three_way_small.cpp control_menu_shadow_bottom.cpp control_menu_shadow_top.cpp controls_background.cpp controls_menu_background.cpp controls_three_way_small_circle.cpp controls_wheel_background.cpp datepicker_bottom_shadow_overlay.cpp datepicker_glass_overlay.cpp datepicker_main_background.cpp datepicker_top_shadow_overlay.cpp gauge_background.cpp gauge_needle_pin.cpp small_circle_bin_icon_active.cpp small_circle_bin_icon_inactive.cpp small_circle_folder_icon_active.cpp small_circle_folder_icon_inactive.cpp small_circle_papers_icon_active.cpp small_circle_papers_icon_inactive.cpp
  group Application/generated/images/EasingEquation
    ../../../../generated/images/src/EasingEquation/: easing_background.cpp easing_bottom_menu.cpp easing_bottom_menu_active.cpp easing_bottom_menu_selected.cpp easing_dot.cpp easing_menu_button.cpp easing_menu_button_pressed.cpp easing_side_menu_button.cpp easing_side_menu_button_active.cpp easing_side_menu_button_selected.cpp graphDot.cpp
  group Application/generated/images/Graph
    ../../../../generated/images/src/Graph/: blue_area_button_active.cpp blue_area_button_inactive.cpp blue_dots_button_active.cpp blue_dots_button_inactive.cpp blue_line_button_active.cpp blue_line_button_inactive.cpp graph_background_bottom.cpp graph_menu_button.cpp graph_menu_button_pressed.cpp graph_toggle_button_active.cpp graph_toggle_button_inactive.cpp graph_top_menu_activate_button.cpp graph_top_menu_line.cpp green_area_button_active.cpp green_area_button_inactive.cpp green_dots_button_active.cpp green_dots_button_inactive.cpp green_line_button_active.cpp green_line_button_inactive.cpp half_circle_toggle_button_active.cpp half_circle_toggle_button_inactive.cpp new_graph.cpp new_graph_pressed.cpp new_pie_chart.cpp new_pie_chart_pressed.cpp pie_chart_legend_blue.cpp pie_chart_legend_blue_active.cpp pie_chart_legend_green.cpp pie_chart_legend_green_active.cpp pie_chart_legend_orange.cpp pie_chart_legend_orange_active.cpp pie_chart_legend_purple.cpp pie_chart_legend_purple_active.cpp pie_chart_legend_red.cpp pie_chart_legend_red_active.cpp pie_chart_legend_yellow.cpp pie_chart_legend_yellow_active.cpp pie_toggle_button_active.cpp pie_toggle_button_inactive.cpp
  group Application/generated/images/MainMenu
    ../../../../generated/images/src/MainMenu/: demo_button_01.cpp demo_button_01_pressed.cpp demo_button_02_03.cpp demo_button_02_03_pressed.cpp demo_button_04.cpp demo_button_04_pressed.cpp demo_button_05_06.cpp demo_button_05_06_pressed.cpp menu_demo_screen_02.cpp menu_demo_screen_03.cpp menu_demo_screen_04.cpp menu_demo_screen_05.cpp menu_stage_stretch_left_side.cpp menu_stage_stretch_right_side.cpp screen_swipe_dots_active.cpp screen_swipe_dots_inactive.cpp
  group Application/generated/images/ProductPresenter
    ../../../../generated/images/src/ProductPresenter/: flag_dnk_active.cpp flag_dnk_inactive.cpp flag_gbr_active.cpp flag_gbr_inactive.cpp flag_jpn_active.cpp flag_jpn_inactive.cpp flag_nld_active.cpp flag_nld_inactive.cpp flag_ukr_active.cpp flag_ukr_inactive.cpp poster_image_00.cpp poster_image_01.cpp poster_image_02.cpp product_presenter_menu_button.cpp product_presenter_menu_button_pressed.cpp product_presenter_nav_bar.cpp product_presenter_next.cpp product_presenter_next_pressed.cpp
  group Application/generated/texts
    ../../../../generated/texts/src/: LanguageDnk.cpp LanguageGbr.cpp LanguageJpn.cpp LanguageNld.cpp LanguageUkr.cpp Texts.cpp TypedTextDatabase.cpp
  group Application/gui/common
    ../../../../gui/src/common/: CollapsibleMenu.cpp DemoPresenter.cpp DotIndicator.cpp FrontendApplication.cpp SwipeContainer.cpp
  group Application/gui/custom_controls_screen
    ../../../../gui/src/custom_controls_screen/: CircularProgress.cpp CustomControlsPresenter.cpp CustomControlsView.cpp DatePicker.cpp Gauge.cpp ThreeWayProgressBar.cpp ThreeWayProgressBarCircle.cpp VerticalSlideMenu.cpp WheelSelector.cpp WheelSelectorExtra.cpp
  group Application/gui/easing_equation_screen
    ../../../../gui/src/easing_equation_screen/: EasingEquationButton.cpp EasingEquationGraph.cpp EasingEquationInOrOutOrInOut.cpp EasingEquationPresenter.cpp EasingEquationSelector.cpp EasingEquationView.cpp
  group Application/gui/graph_screen
    ../../../../gui/src/graph_screen/: AbstractGraph.cpp Graph.cpp GraphBelow.cpp GraphDots.cpp GraphLine.cpp GraphPresenter.cpp GraphView.cpp LegendEntry.cpp PainterVerticalAlpha.cpp PieChart.cpp
  group Application/gui/main_menu_screen
    ../../../../gui/src/main_menu_screen/: MainMenuPresenter.cpp MainMenuView.cpp
  group Application/gui/model
    ../../../../gui/src/model/: Model.cpp
  group Application/gui/product_presenter_screen
    ../../../../gui/src/product_presenter_screen/: ProductPresenterPresenter.cpp ProductPresenterView.cpp
  group Application/main
    ../../../: main.cpp
  group CubeF4/Board
    ../../../../../../../touchgfx/board/ST/STM324x9I-CUBE/source/vendor/STM324x9I_EVAL/: stm324x9i_eval.c stm324x9i_eval_lcd.c stm324x9i_eval_nor.c stm324x9i_eval_sdram.c stm324x9i_eval_sram.c stm324x9i_eval_ts.c
    ../../../../../../../touchgfx/board/ST/STM324x9I-CUBE/source/vendor/Components/stmpe811/: stmpe811.c
    ../../../../../../../touchgfx/board/ST/STM324x9I-CUBE/source/vendor/Components/ts3510/: ts3510.c
    ../../../../../../../touchgfx/board/ST/STM324x9I-CUBE/source/vendor/Components/exc7200/: exc7200.c
  group CubeF4/MCU
    ../../../../../../../touchgfx/framework/source/platform/hal/ST/mcu/stm32f4cube/IAR/: startup_stm32f429xx.s
    ../../../../../../../touchgfx/framework/source/platform/hal/ST/mcu/stm32f4cube/STM32F4xx_HAL_Driver/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_nor.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sdram.c stm32f4xx_hal_sram.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c
    ../../../../../../../touchgfx/framework/source/platform/hal/ST/mcu/stm32f4cube/CMSIS/: system_stm32f4xx.c
  group OS
    ../../../../../../../touchgfx/os/FreeRTOS7.6.0/: OSWrappers.cpp
  group OS/FreeRTOS7.6.0
    ../../../../../../../touchgfx/os/FreeRTOS7.6.0/Source/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../../../../touchgfx/os/FreeRTOS7.6.0/Source/portable/MemMang/: heap_2.c
  group OS/FreeRTOS7.6.0/portable
    ../../../../../../../touchgfx/os/FreeRTOS7.6.0/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group TouchGFXPort/Board
    ../../../../../../../touchgfx/board/ST/STM324x9I-CUBE/source/: BoardConfiguration.cpp GPIO.cpp
    ../../../../../../../touchgfx/board/ST/STM324x9I-CUBE/source/bsp/: STM324x9IButtonController.cpp STM324x9ITouchController.cpp
  group TouchGFXPort/MCU
    ../../../../../../../touchgfx/framework/source/platform/core/arm/cortex-m/: CortexMMCUInstrumentation.cpp
    ../../../../../../../touchgfx/framework/source/platform/hal/ST/mcu/stm32f4cube/: STM32F4DMA.cpp STM32F4HAL.cpp

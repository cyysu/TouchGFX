# IAR project application.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429NI ST STM32F429NI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: ST; STM32F756xx; USE_FREERTOS_8; USE_OS_SYSTICK; USE_STM32746G_DISCOVERY
  ICCARM.CCIncludePath2: ..\..\..\..\gui\include; ..\..\..\..\target\include; ..\..\..\..\platform\os; ..\..\..\..\generated\fonts\include; ..\..\..\..\generated\images\include; ..\..\..\..\generated\texts\include; ..\..\..\..\..\..\..\touchgfx\framework\include; ..\..\..\..\..\..\..\touchgfx\framework\include\platform\core\arm\cortex-m\CMSIS; ..\..\..\..\..\..\..\touchgfx\framework\include\platform\hal\ST\mcu\stm32f7xx\; ..\..\..\..\..\..\..\touchgfx\framework\include\platform\hal\ST\mcu\stm32f7xx\CMSIS; ..\..\..\..\..\..\..\touchgfx\framework\include\platform\hal\ST\mcu\stm32f7xx\STM32F7xx_HAL_Driver; ..\..\..\..\..\..\..\touchgfx\board\ST\STM32F746G-DISCO\include; ..\..\..\..\..\..\..\touchgfx\board\ST\STM32F746G-DISCO\include\vendor; ..\..\..\..\..\..\..\touchgfx\board\ST\STM32F746G-DISCO\source\vendor\STM32746G-Discovery; ..\..\..\..\..\..\..\touchgfx\os\FreeRTOS8.2.0\Source\include; ..\..\..\..\..\..\..\touchgfx\os\FreeRTOS8.2.0\Source\portable\IAR\ST_CM7
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: USE_FREERTOS_8; USE_OS_SYSTICK
  AARM.AUserIncludes: ..\..\..\..\platform\os; ..\..\..\..\..\framework\touchgfx\platform\core\arm\cortex-m\CMSIS\include; ..\..\..\..\..\framework\touchgfx\platform\hal\ST\board\STM32429I-EVAL1\include; ..\..\..\..\..\framework\touchgfx\platform\hal\ST\board\STM32429I-EVAL1\src; ..\..\..\..\..\framework\touchgfx\platform\hal\ST\mcu\stm32f4x9\inc; ..\..\..\..\..\framework\touchgfx\platform\os\FreeRTOS7.6.0\Source\include; ..\..\..\..\..\framework\touchgfx\platform\os\FreeRTOS7.6.0\Source\portable\IAR\ARM_CM4F
  OBJCOPY.OOCOutputFile: application.hex
  ILINK.IlinkOutputFile: application.out
  ILINK.IlinkIcfFile: application.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\..\touchgfx\lib\core\cortex_m7\IAR\touchgfx_core.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/generated/fonts
    ../../../../generated/fonts/src/: ApplicationFontProvider.cpp Font_Asap_Bold_otf_12_4bpp.cpp Font_Asap_Bold_otf_15_4bpp.cpp Font_Asap_Bold_otf_18_4bpp.cpp Font_Asap_Bold_otf_46_4bpp.cpp Font_Asap_Regular_11_4bpp.cpp Font_Asap_Regular_12_4bpp.cpp Font_Asap_Regular_15_4bpp.cpp Font_Asap_Regular_18_4bpp.cpp Font_ipaexg_12_4bpp.cpp Font_ipaexg_18_4bpp.cpp Font_NotoSans_Regular_12_4bpp.cpp Font_NotoSans_Regular_18_4bpp.cpp FontGetters.cpp Kerning_Asap_Bold_otf_12_4bpp.cpp Kerning_Asap_Bold_otf_15_4bpp.cpp Kerning_Asap_Bold_otf_18_4bpp.cpp Kerning_Asap_Bold_otf_46_4bpp.cpp Kerning_Asap_Regular_11_4bpp.cpp Kerning_Asap_Regular_12_4bpp.cpp Kerning_Asap_Regular_15_4bpp.cpp Kerning_Asap_Regular_18_4bpp.cpp Kerning_ipaexg_12_4bpp.cpp Kerning_ipaexg_18_4bpp.cpp Kerning_NotoSans_Regular_12_4bpp.cpp Kerning_NotoSans_Regular_18_4bpp.cpp Table_Asap_Bold_otf_12_4bpp.cpp Table_Asap_Bold_otf_15_4bpp.cpp Table_Asap_Bold_otf_18_4bpp.cpp Table_Asap_Bold_otf_46_4bpp.cpp Table_Asap_Regular_11_4bpp.cpp Table_Asap_Regular_12_4bpp.cpp Table_Asap_Regular_15_4bpp.cpp Table_Asap_Regular_18_4bpp.cpp Table_ipaexg_12_4bpp.cpp Table_ipaexg_18_4bpp.cpp Table_NotoSans_Regular_12_4bpp.cpp Table_NotoSans_Regular_18_4bpp.cpp
  group Application/generated/images
    ../../../../generated/images/src/: BitmapDatabase.cpp
  group Application/generated/images/CustomControls
    ../../../../generated/images/src/CustomControls/: control_center_button.cpp control_center_button_pressed.cpp control_color_wheel.cpp control_menu_arrow_down.cpp control_menu_arrow_down_inactive.cpp control_menu_arrow_down_pressed.cpp control_menu_arrow_up-inactive.cpp control_menu_arrow_up-pressed.cpp control_menu_arrow_up.cpp control_menu_button.cpp control_menu_button_pressed.cpp control_menu_icon_datepicker_large.cpp control_menu_icon_datepicker_small.cpp control_menu_icon_gauge_large.cpp control_menu_icon_gauge_small.cpp control_menu_icon_percentage_large.cpp control_menu_icon_percentage_small.cpp control_menu_icon_three_way_large.cpp control_menu_icon_three_way_small.cpp control_menu_shadow_bottom.cpp control_menu_shadow_top.cpp controls_background.cpp controls_menu_background.cpp controls_three_way_small_circle.cpp controls_wheel_background.cpp datepicker_bottom_shadow_overlay.cpp datepicker_glass_overlay.cpp datepicker_main_background.cpp datepicker_top_shadow_overlay.cpp gauge_background.cpp gauge_needle_pin.cpp small_circle_bin_icon_active.cpp small_circle_bin_icon_inactive.cpp small_circle_folder_icon_active.cpp small_circle_folder_icon_inactive.cpp small_circle_papers_icon_active.cpp small_circle_papers_icon_inactive.cpp
  group Application/generated/images/EasingEquation
    ../../../../generated/images/src/EasingEquation/: easing_background.cpp easing_bottom_menu.cpp easing_bottom_menu_active.cpp easing_bottom_menu_selected.cpp easing_dot.cpp easing_menu_button.cpp easing_menu_button_pressed.cpp easing_side_menu_button.cpp easing_side_menu_button_active.cpp easing_side_menu_button_selected.cpp graphDot.cpp
  group Application/generated/images/Graph
    ../../../../generated/images/src/Graph/: blue_area_button_active.cpp blue_area_button_inactive.cpp blue_dots_button_active.cpp blue_dots_button_inactive.cpp blue_line_button_active.cpp blue_line_button_inactive.cpp graph_background_bottom.cpp graph_menu_button.cpp graph_menu_button_pressed.cpp graph_toggle_button_active.cpp graph_toggle_button_inactive.cpp graph_top_menu_activate_button.cpp graph_top_menu_line.cpp green_area_button_active.cpp green_area_button_inactive.cpp green_dots_button_active.cpp green_dots_button_inactive.cpp green_line_button_active.cpp green_line_button_inactive.cpp half_circle_toggle_button_active.cpp half_circle_toggle_button_inactive.cpp new_graph.cpp new_graph_pressed.cpp new_pie_chart.cpp new_pie_chart_pressed.cpp pie_chart_legend_blue.cpp pie_chart_legend_blue_active.cpp pie_chart_legend_green.cpp pie_chart_legend_green_active.cpp pie_chart_legend_orange.cpp pie_chart_legend_orange_active.cpp pie_chart_legend_purple.cpp pie_chart_legend_purple_active.cpp pie_chart_legend_red.cpp pie_chart_legend_red_active.cpp pie_chart_legend_yellow.cpp pie_chart_legend_yellow_active.cpp pie_toggle_button_active.cpp pie_toggle_button_inactive.cpp
  group Application/generated/images/MainMenu
    ../../../../generated/images/src/MainMenu/: demo_button_01.cpp demo_button_01_pressed.cpp demo_button_02_03.cpp demo_button_02_03_pressed.cpp demo_button_04.cpp demo_button_04_pressed.cpp demo_button_05_06.cpp demo_button_05_06_pressed.cpp menu_demo_screen_02.cpp menu_demo_screen_03.cpp menu_demo_screen_04.cpp menu_demo_screen_05.cpp menu_stage_stretch_left_side.cpp menu_stage_stretch_right_side.cpp screen_swipe_dots_active.cpp screen_swipe_dots_inactive.cpp
  group Application/generated/images/ProductPresenter
    ../../../../generated/images/src/ProductPresenter/: flag_dnk_active.cpp flag_dnk_inactive.cpp flag_gbr_active.cpp flag_gbr_inactive.cpp flag_jpn_active.cpp flag_jpn_inactive.cpp flag_nld_active.cpp flag_nld_inactive.cpp flag_ukr_active.cpp flag_ukr_inactive.cpp poster_image_00.cpp poster_image_01.cpp poster_image_02.cpp product_presenter_menu_button.cpp product_presenter_menu_button_pressed.cpp product_presenter_nav_bar.cpp product_presenter_next.cpp product_presenter_next_pressed.cpp
  group Application/generated/texts
    ../../../../generated/texts/src/: LanguageDnk.cpp LanguageGbr.cpp LanguageJpn.cpp LanguageNld.cpp LanguageUkr.cpp Texts.cpp TypedTextDatabase.cpp
  group Application/gui/common
    ../../../../gui/src/common/: CollapsibleMenu.cpp DemoPresenter.cpp DotIndicator.cpp FrontendApplication.cpp SwipeContainer.cpp
  group Application/gui/custom_controls_screen
    ../../../../gui/src/custom_controls_screen/: CircularProgress.cpp CustomControlsPresenter.cpp CustomControlsView.cpp DatePicker.cpp Gauge.cpp ThreeWayProgressBar.cpp ThreeWayProgressBarCircle.cpp VerticalSlideMenu.cpp WheelSelector.cpp WheelSelectorExtra.cpp
  group Application/gui/easing_equation_screen
    ../../../../gui/src/easing_equation_screen/: EasingEquationButton.cpp EasingEquationGraph.cpp EasingEquationInOrOutOrInOut.cpp EasingEquationPresenter.cpp EasingEquationSelector.cpp EasingEquationView.cpp
  group Application/gui/graph_screen
    ../../../../gui/src/graph_screen/: AbstractGraph.cpp Graph.cpp GraphBelow.cpp GraphDots.cpp GraphLine.cpp GraphPresenter.cpp GraphView.cpp LegendEntry.cpp PainterVerticalAlpha.cpp PieChart.cpp
  group Application/gui/main_menu_screen
    ../../../../gui/src/main_menu_screen/: MainMenuPresenter.cpp MainMenuView.cpp
  group Application/gui/model
    ../../../../gui/src/model/: Model.cpp
  group Application/gui/product_presenter_screen
    ../../../../gui/src/product_presenter_screen/: ProductPresenterPresenter.cpp ProductPresenterView.cpp
  group Application/main
    ../../../: main.cpp
  group Board/STM32F746G-DISCO
    ../../../../../../../touchgfx/board/ST/STM32F746G-DISCO/source/: BoardConfiguration.cpp GPIO.cpp
  group Board/STM32F746G-DISCO/BSP
    ../../../../../../../touchgfx/board/ST/STM32F746G-DISCO/source/bsp/: STM32F746GTouchController.cpp STM32F7Instrumentation.cpp
  group Board/STM32F746G-DISCO/Vendor
    ../../../../../../../touchgfx/board/ST/STM32F746G-DISCO/source/vendor/Components/ft5336/: ft5336.c
    ../../../../../../../touchgfx/board/ST/STM32F746G-DISCO/source/vendor/STM32746G-Discovery/: stm32746g_discovery.c stm32746g_discovery_lcd.c stm32746g_discovery_qspi.c stm32746g_discovery_sd.c stm32746g_discovery_sdram.c stm32746g_discovery_ts.c
  group MCU
    ../../../../../../../touchgfx/framework/source/platform/hal/ST/mcu/stm32f7xx/: STM32F7DMA.cpp STM32F7HAL.cpp
  group MCU/stm32f7xx
    ../../../../../../../touchgfx/framework/source/platform/hal/ST/mcu/stm32f7xx/IAR/: startup_stm32f746xx.s
    ../../../../../../../touchgfx/framework/source/platform/hal/ST/mcu/stm32f7xx/STM32F7xx_HAL_Driver/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_cec.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_eth.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_irda.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_lptim.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_msp_template.c stm32f7xx_hal_nand.c stm32f7xx_hal_nor.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_wwdg.c stm32f7xx_ll_fmc.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_usb.c
    ../../../../../../../touchgfx/framework/source/platform/hal/ST/mcu/stm32f7xx/CMSIS/: system_stm32f7xx.c
  group OS
    ../../../../../../../touchgfx/os/FreeRTOS8.2.0/: OSWrappers.cpp
  group OS/FreeRTOS8.2.0
    ../../../../../../../touchgfx/os/FreeRTOS8.2.0/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../../../touchgfx/os/FreeRTOS8.2.0/Source/portable/MemMang/: heap_2.c
    ../../../../../../../touchgfx/os/FreeRTOS8.2.0/Source/portable/IAR/ST_CM7/: port.c portasm.s

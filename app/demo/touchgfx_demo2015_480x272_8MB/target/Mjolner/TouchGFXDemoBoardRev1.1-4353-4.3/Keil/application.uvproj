# Keil uVision project application.uvproj, settings and files
target Internal Flash and SPIFI (ARM-ADS)
  device: LPC4353 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x1A000000-0x1A03FFFF) IROM2(0x1B000000-0x1B03FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: application
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x1A000000)
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=4
  c define: CORE_M4 NXP DISPLAY_UMSH_8253MD_3T
  c include: ..\..\..\..\..\..\..\touchgfx\framework\include;..\..\..\..\..\..\..\touchgfx\os\FreeRTOS7.6.0\Source\include;..\..\..\..\..\..\..\touchgfx\os\FreeRTOS7.6.0\Source\portable\RVDS\ARM_CM4F;..\..\..\..\platform\os;..\..\..\..\gui\include;..\..\..\..\target\include;..\..\..\..\generated\fonts\include;..\..\..\..\generated\images\include;..\..\..\..\generated\texts\include;..\..\..\..\..\..\..\touchgfx\framework\include\platform\hal\nxp\mcu\LPC43xx\vendor;..\..\..\..\..\..\..\touchgfx\framework\include\platform\core\arm\cortex-m\CMSIS;..\..\..\..\..\..\..\touchgfx\framework\source\platform\hal\nxp\lpcspifilib\inc;..\..\..\..\..\..\..\touchgfx\board\Mjolner\Common\include\bsp;..\..\..\..\..\..\..\touchgfx\board\Mjolner\Common\source\vendor;..\..\..\..\..\..\..\touchgfx\board\Mjolner\Common\source\vendor\lpc_core\lpc_ip;..\..\..\..\..\..\..\touchgfx\board\Mjolner\Common\source\vendor\lpc_core\lpc_chip\chip_18xx_43xx
  memory RVCT4: ROM 0x1a000000 size 0x40000
  memory RVCT5: ROM 0x1b000000 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\Flash.sct
  group Gui
    ../../../../gui/src/graph_screen/: AbstractGraph.cpp Graph.cpp GraphBelow.cpp GraphDots.cpp GraphLine.cpp GraphPresenter.cpp GraphView.cpp LegendEntry.cpp PainterVerticalAlpha.cpp PieChart.cpp
    ../../../../gui/src/custom_controls_screen/: CircularProgress.cpp CustomControlsPresenter.cpp CustomControlsView.cpp DatePicker.cpp Gauge.cpp ThreeWayProgressBar.cpp ThreeWayProgressBarCircle.cpp VerticalSlideMenu.cpp WheelSelector.cpp WheelSelectorExtra.cpp
    ../../../../gui/src/common/: CollapsibleMenu.cpp DemoPresenter.cpp DotIndicator.cpp FrontendApplication.cpp SwipeContainer.cpp
    ../../../../gui/src/easing_equation_screen/: EasingEquationButton.cpp EasingEquationGraph.cpp EasingEquationInOrOutOrInOut.cpp EasingEquationPresenter.cpp EasingEquationSelector.cpp EasingEquationView.cpp
    ../../../../gui/src/main_menu_screen/: MainMenuPresenter.cpp MainMenuView.cpp
    ../../../../gui/src/model/: Model.cpp
    ../../../../gui/src/product_presenter_screen/: ProductPresenterPresenter.cpp ProductPresenterView.cpp
  group Generated
    ../../../../generated/fonts/src/: ApplicationFontProvider.cpp Font_Asap_Bold_otf_12_4bpp.cpp Font_Asap_Bold_otf_15_4bpp.cpp Font_Asap_Bold_otf_18_4bpp.cpp Font_Asap_Bold_otf_46_4bpp.cpp Font_Asap_Regular_11_4bpp.cpp Font_Asap_Regular_12_4bpp.cpp Font_Asap_Regular_15_4bpp.cpp Font_Asap_Regular_18_4bpp.cpp Font_ipaexg_12_4bpp.cpp Font_ipaexg_18_4bpp.cpp Font_NotoSans_Regular_12_4bpp.cpp Font_NotoSans_Regular_18_4bpp.cpp FontGetters.cpp Kerning_Asap_Bold_otf_12_4bpp.cpp Kerning_Asap_Bold_otf_15_4bpp.cpp Kerning_Asap_Bold_otf_18_4bpp.cpp Kerning_Asap_Bold_otf_46_4bpp.cpp Kerning_Asap_Regular_11_4bpp.cpp Kerning_Asap_Regular_12_4bpp.cpp Kerning_Asap_Regular_15_4bpp.cpp Kerning_Asap_Regular_18_4bpp.cpp Kerning_ipaexg_12_4bpp.cpp Kerning_ipaexg_18_4bpp.cpp Kerning_NotoSans_Regular_12_4bpp.cpp Kerning_NotoSans_Regular_18_4bpp.cpp Table_Asap_Bold_otf_12_4bpp.cpp Table_Asap_Bold_otf_15_4bpp.cpp Table_Asap_Bold_otf_18_4bpp.cpp Table_Asap_Bold_otf_46_4bpp.cpp Table_Asap_Regular_11_4bpp.cpp Table_Asap_Regular_12_4bpp.cpp Table_Asap_Regular_15_4bpp.cpp Table_Asap_Regular_18_4bpp.cpp Table_ipaexg_12_4bpp.cpp Table_ipaexg_18_4bpp.cpp Table_NotoSans_Regular_12_4bpp.cpp Table_NotoSans_Regular_18_4bpp.cpp
    ../../../../generated/images/src/: BitmapDatabase.cpp
    ../../../../generated/images/src/Graph/: blue_area_button_active.cpp blue_area_button_inactive.cpp blue_dots_button_active.cpp blue_dots_button_inactive.cpp blue_line_button_active.cpp blue_line_button_inactive.cpp graph_background_bottom.cpp graph_menu_button.cpp graph_menu_button_pressed.cpp graph_toggle_button_active.cpp graph_toggle_button_inactive.cpp graph_top_menu_activate_button.cpp graph_top_menu_line.cpp green_area_button_active.cpp green_area_button_inactive.cpp green_dots_button_active.cpp green_dots_button_inactive.cpp green_line_button_active.cpp green_line_button_inactive.cpp half_circle_toggle_button_active.cpp half_circle_toggle_button_inactive.cpp new_graph.cpp new_graph_pressed.cpp new_pie_chart.cpp new_pie_chart_pressed.cpp pie_chart_legend_blue.cpp pie_chart_legend_blue_active.cpp pie_chart_legend_green.cpp pie_chart_legend_green_active.cpp pie_chart_legend_orange.cpp pie_chart_legend_orange_active.cpp pie_chart_legend_purple.cpp pie_chart_legend_purple_active.cpp pie_chart_legend_red.cpp pie_chart_legend_red_active.cpp pie_chart_legend_yellow.cpp pie_chart_legend_yellow_active.cpp pie_toggle_button_active.cpp pie_toggle_button_inactive.cpp
    ../../../../generated/images/src/CustomControls/: control_center_button.cpp control_center_button_pressed.cpp control_color_wheel.cpp control_menu_arrow_down.cpp control_menu_arrow_down_inactive.cpp control_menu_arrow_down_pressed.cpp control_menu_arrow_up-inactive.cpp control_menu_arrow_up-pressed.cpp control_menu_arrow_up.cpp control_menu_button.cpp control_menu_button_pressed.cpp control_menu_icon_datepicker_large.cpp control_menu_icon_datepicker_small.cpp control_menu_icon_gauge_large.cpp control_menu_icon_gauge_small.cpp control_menu_icon_percentage_large.cpp control_menu_icon_percentage_small.cpp control_menu_icon_three_way_large.cpp control_menu_icon_three_way_small.cpp control_menu_shadow_bottom.cpp control_menu_shadow_top.cpp controls_background.cpp controls_menu_background.cpp controls_three_way_small_circle.cpp controls_wheel_background.cpp datepicker_bottom_shadow_overlay.cpp datepicker_glass_overlay.cpp datepicker_main_background.cpp datepicker_top_shadow_overlay.cpp gauge_background.cpp gauge_needle_pin.cpp small_circle_bin_icon_active.cpp small_circle_bin_icon_inactive.cpp small_circle_folder_icon_active.cpp small_circle_folder_icon_inactive.cpp small_circle_papers_icon_active.cpp small_circle_papers_icon_inactive.cpp
    ../../../../generated/images/src/MainMenu/: demo_button_01.cpp demo_button_01_pressed.cpp demo_button_02_03.cpp demo_button_02_03_pressed.cpp demo_button_04.cpp demo_button_04_pressed.cpp demo_button_05_06.cpp demo_button_05_06_pressed.cpp menu_demo_screen_02.cpp menu_demo_screen_03.cpp menu_demo_screen_04.cpp menu_demo_screen_05.cpp menu_stage_stretch_left_side.cpp menu_stage_stretch_right_side.cpp screen_swipe_dots_active.cpp screen_swipe_dots_inactive.cpp
    ../../../../generated/images/src/EasingEquation/: easing_background.cpp easing_bottom_menu.cpp easing_bottom_menu_active.cpp easing_bottom_menu_selected.cpp easing_dot.cpp easing_menu_button.cpp easing_menu_button_pressed.cpp easing_side_menu_button.cpp easing_side_menu_button_active.cpp easing_side_menu_button_selected.cpp graphDot.cpp
    ../../../../generated/images/src/ProductPresenter/: flag_dnk_active.cpp flag_dnk_inactive.cpp flag_gbr_active.cpp flag_gbr_inactive.cpp flag_jpn_active.cpp flag_jpn_inactive.cpp flag_nld_active.cpp flag_nld_inactive.cpp flag_ukr_active.cpp flag_ukr_inactive.cpp poster_image_00.cpp poster_image_01.cpp poster_image_02.cpp product_presenter_menu_button.cpp product_presenter_menu_button_pressed.cpp product_presenter_nav_bar.cpp product_presenter_next.cpp product_presenter_next_pressed.cpp
    ../../../../generated/texts/src/: LanguageDnk.cpp LanguageGbr.cpp LanguageJpn.cpp LanguageNld.cpp LanguageUkr.cpp Texts.cpp TypedTextDatabase.cpp
  group Startup
    ../../../: main.cpp
    ../../../../../../../touchgfx/framework/source/platform/hal/nxp/mcu/LPC43xx/Keil/: startup_LPC43xx.s
  group TouchGFXHAL
    ../../../../../../../touchgfx/board/Mjolner/Common/source/bsp/: Buttons.cpp LED.cpp
    ../../../../../../../touchgfx/framework/source/platform/core/arm/cortex-m/: CortexMMCUInstrumentation.cpp
    ../../../../../../../touchgfx/framework/source/platform/hal/nxp/mcu/LPC43xx/driver/i2c/: I2C_LPC43xx.cpp
    ../../../../../../../touchgfx/board/Mjolner/Common/source/: GPIO.cpp
    ../../../../../../../touchgfx/framework/source/platform/driver/touch/: ST1232TouchController.cpp
    ../../../../../../../touchgfx/board/Mjolner/TouchGFXDemoBoardRev1.1-4353-4.3/source/: BoardConfiguration.cpp
    ../../../../../../../touchgfx/framework/source/platform/hal/nxp/mcu/LPC43xx/: NXP43XXDMA.cpp NXP43XXHAL.cpp
  group HAL
    ../../../../../../../touchgfx/framework/source/platform/hal/nxp/lpcspifilib/src/: spifilib_dev_common.c spifilib_fam_mac_2b_stat.c spifilib_fam_spa_3b_stat.c spifilib_fam_spa_2b_pstat.c
    ../../../../../../../touchgfx/board/Mjolner/Common/source/bsp/: BoardInit.c KeySampler.cpp SystemInit.c SystemPinConfig.c
    ../../../../../../../touchgfx/framework/source/platform/hal/nxp/mcu/LPC43xx/vendor/: lpc43xx_uart.c lpc43xx_ssp.c lpc43xx_timer.c lpc43xx_rgu.c lpc43xx_scu.c lpc43xx_lcd.c lpc43xx_cgu.c lpc43xx_i2c.c lpc43xx_gpio.c lpc43xx_gpdma.c lpc43xx_emc.c lpc43xx_adc.c
    ../../../../../../../touchgfx/board/Mjolner/Common/source/vendor/lpc_core/lpc_chip/chip_18xx_43xx/: clock_18xx_43xx.c emc_18xx_43xx.c lcd_18xx_43xx.c rgu_18xx_43xx.c ssp_18xx_43xx.c
    ../../../../../../../touchgfx/board/Mjolner/Common/source/vendor/lpc_core/lpc_ip/: emc_001.c lcd_001.c ssp_001.c
  group OS
    ../../../../../../../touchgfx/os/FreeRTOS7.6.0/: OSWrappers.cpp
    ../../../../../../../touchgfx/os/FreeRTOS7.6.0/Source/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../../../../touchgfx/os/FreeRTOS7.6.0/Source/portable/MemMang/: heap_2.c
    ../../../../../../../touchgfx/os/FreeRTOS7.6.0/Source/portable/RVDS/ARM_CM4F/: port.c
  group Lib
    ../../../../../../../touchgfx/lib/core/cortex_m4f/Keil/: touchgfx_core.lib

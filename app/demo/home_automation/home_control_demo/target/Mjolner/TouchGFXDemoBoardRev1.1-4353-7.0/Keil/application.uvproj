# Keil uVision project application.uvproj, settings and files
target Internal Flash and SPIFI (ARM-ADS)
  device: LPC4353 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x1A000000-0x1A03FFFF) IROM2(0x1B000000-0x1B03FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: application
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x1A000000)
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=4
  c define: CORE_M4 NXP DISPLAY_UMSH_8596MD_T
  c include: ..\..\..\..\..\..\..\..\touchgfx\framework\include;..\..\..\..\..\..\..\..\touchgfx\os\FreeRTOS7.6.0\Source\include;..\..\..\..\..\..\..\..\touchgfx\os\FreeRTOS7.6.0\Source\portable\RVDS\ARM_CM4F;..\..\..\..\platform\os;..\..\..\..\gui\include;..\..\..\..\target\include;..\..\..\..\generated\fonts\include;..\..\..\..\generated\images\include;..\..\..\..\generated\texts\include;..\..\..\..\..\..\..\..\touchgfx\framework\include\platform\hal\nxp\mcu\LPC43xx\vendor;..\..\..\..\..\..\..\..\touchgfx\framework\include\platform\core\arm\cortex-m\CMSIS;..\..\..\..\..\..\..\..\touchgfx\framework\source\platform\hal\nxp\lpcspifilib\inc;..\..\..\..\..\..\..\..\touchgfx\board\Mjolner\Common\include\bsp;..\..\..\..\..\..\..\..\touchgfx\board\Mjolner\Common\source\vendor;..\..\..\..\..\..\..\..\touchgfx\board\Mjolner\Common\source\vendor\lpc_core\lpc_ip;..\..\..\..\..\..\..\..\touchgfx\board\Mjolner\Common\source\vendor\lpc_core\lpc_chip\chip_18xx_43xx
  memory RVCT4: ROM 0x1a000000 size 0x40000
  memory RVCT5: ROM 0x1b000000 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\Flash.sct
  group Gui
    ../../../../gui/src/air_condition_screen/: AirConditionPresenter.cpp AirConditionView.cpp
    ../../../../gui/src/model/: AlbumManager.cpp Model.cpp WashingMachine.cpp
    ../../../../gui/src/appliances_screen/: AppliancesPresenter.cpp AppliancesView.cpp
    ../../../../gui/src/common/: BasePresenter.cpp BlindsSelector.cpp Constants.cpp DotIndicator.cpp FadeTransition.cpp FrontendApplication.cpp JogWheel.cpp MainMenu.cpp MenuButton.cpp RoomSelector.cpp SelectionButton.cpp SwipeContainer.cpp
    ../../../../gui/src/blinds_screen/: BlindsPresenter.cpp BlindsView.cpp
    ../../../../gui/src/system/: Clock.cpp
    ../../../../gui/src/tiles/: ClockTile.cpp ImageTile.cpp MusicPlayerTile.cpp TopTile.cpp WashingMachineTile.cpp WeatherTile.cpp WeatherTileDayElement.cpp
    ../../../../gui/src/entertainment_screen/: EntertainmentPresenter.cpp EntertainmentView.cpp
    ../../../../gui/src/home_screen/: HomePresenter.cpp HomeView.cpp
    ../../../../gui/src/lighting_screen/: LightingPresenter.cpp LightingView.cpp
    ../../../../gui/src/security_screen/: SecurityPresenter.cpp SecurityRoomSelector.cpp SecurityView.cpp
    ../../../../gui/src/settings_screen/: SettingsPresenter.cpp SettingsSlider.cpp SettingsView.cpp
  group Generated
    ../../../../generated/images/src/air_condition/: air_con_headline.cpp air_con_schedule_button.cpp air_con_schedule_button_pressed.cpp bed_room_selected.cpp jogwheel_normal.cpp jogwheel_pressed.cpp kitchen_selected.cpp living_room_selected.cpp room1_selected.cpp room2_selected.cpp room_layout.cpp
    ../../../../generated/images/src/idle/: air_con_top.cpp blinds_top.cpp dishwasher_tile.cpp dishwasher_tile_small.cpp dot_active.cpp dot_inactive.cpp lighting_top.cpp pause_button.cpp pause_button_pressed.cpp play_button.cpp play_button_pressed.cpp tumble_dryer_tile.cpp tumble_dryer_tile_small.cpp vert_line_buttom.cpp vert_line_top.cpp weather_bar.cpp
    ../../../../generated/images/src/menu/: aircon_hover.cpp aircon_normal.cpp aircon_pressed.cpp appliances_hover.cpp appliances_normal.cpp appliances_pressed.cpp blinds_hover.cpp blinds_normal.cpp blinds_pressed.cpp entertainment_hover.cpp entertainment_normal.cpp entertainment_pressed.cpp lighting_hover.cpp lighting_normal.cpp lighting_pressed.cpp security_hover.cpp security_normal.cpp security_pressed.cpp settings_hover.cpp settings_normal.cpp settings_pressed.cpp
    ../../../../generated/images/src/: appliances_inactive.cpp background.cpp BitmapDatabase.cpp
    ../../../../generated/fonts/src/: ApplicationFontProvider.cpp Font_MavenPro_Medium_12_8bpp.cpp Font_MavenPro_Medium_14_8bpp.cpp Font_MavenPro_Medium_15_8bpp.cpp Font_MavenPro_Medium_16_8bpp.cpp Font_MavenPro_Medium_18_8bpp.cpp Font_MavenPro_Medium_20_8bpp.cpp Font_MavenPro_Medium_32_8bpp.cpp Font_MavenPro_Medium_40_8bpp.cpp Font_MavenPro_Medium_45_8bpp.cpp Font_MavenPro_Medium_75_8bpp.cpp Font_MavenPro_Regular_14_8bpp.cpp Font_MavenPro_Regular_35_8bpp.cpp FontGetters.cpp Kerning_MavenPro_Medium_12_8bpp.cpp Kerning_MavenPro_Medium_14_8bpp.cpp Kerning_MavenPro_Medium_15_8bpp.cpp Kerning_MavenPro_Medium_16_8bpp.cpp Kerning_MavenPro_Medium_18_8bpp.cpp Kerning_MavenPro_Medium_20_8bpp.cpp Kerning_MavenPro_Medium_32_8bpp.cpp Kerning_MavenPro_Medium_40_8bpp.cpp Kerning_MavenPro_Medium_45_8bpp.cpp Kerning_MavenPro_Medium_75_8bpp.cpp Kerning_MavenPro_Regular_14_8bpp.cpp Kerning_MavenPro_Regular_35_8bpp.cpp Table_MavenPro_Medium_12_8bpp.cpp Table_MavenPro_Medium_14_8bpp.cpp Table_MavenPro_Medium_15_8bpp.cpp Table_MavenPro_Medium_16_8bpp.cpp Table_MavenPro_Medium_18_8bpp.cpp Table_MavenPro_Medium_20_8bpp.cpp Table_MavenPro_Medium_32_8bpp.cpp Table_MavenPro_Medium_40_8bpp.cpp Table_MavenPro_Medium_45_8bpp.cpp Table_MavenPro_Medium_75_8bpp.cpp Table_MavenPro_Regular_14_8bpp.cpp Table_MavenPro_Regular_35_8bpp.cpp
    ../../../../generated/images/src/entertainment/: back_normal.cpp back_pressed.cpp Entertainment_headline.cpp next_normal.cpp next_pressed.cpp play_normal.cpp play_pressed.cpp shadow_large_left.cpp shadow_large_right.cpp shadow_small_left.cpp shadow_small_right.cpp top_navi.cpp
    ../../../../generated/images/src/blinds/: blind_selector_pressed.cpp blinds_headline.cpp blinds_schedule_button.cpp jogwheel_percentage.cpp room_layout_blinds.cpp
    ../../../../generated/images/src/idle/covers_100/: cover100_0.cpp cover100_1.cpp cover100_2.cpp cover100_3.cpp cover100_4.cpp cover100_5.cpp cover100_6.cpp cover100_7.cpp cover100_8.cpp cover100_9.cpp
    ../../../../generated/images/src/entertainment/covers_160/: cover160_0.cpp cover160_1.cpp cover160_2.cpp cover160_3.cpp cover160_4.cpp cover160_5.cpp cover160_6.cpp cover160_7.cpp cover160_8.cpp cover160_9.cpp
    ../../../../generated/images/src/entertainment/covers_200/: cover200_0.cpp cover200_1.cpp cover200_2.cpp cover200_3.cpp cover200_4.cpp cover200_5.cpp cover200_6.cpp cover200_7.cpp cover200_8.cpp cover200_9.cpp
    ../../../../generated/images/src/entertainment/covers_240/: cover240_0.cpp cover240_1.cpp cover240_2.cpp cover240_3.cpp cover240_4.cpp cover240_5.cpp cover240_6.cpp cover240_7.cpp cover240_8.cpp cover240_9.cpp
    ../../../../generated/images/src/idle/weather_tile/: icon_cloudy.cpp icon_lightning.cpp icon_rain.cpp icon_rain_sun.cpp icon_sun.cpp
    ../../../../generated/texts/src/: LanguageGb.cpp Texts.cpp TypedTextDatabase.cpp
    ../../../../generated/images/src/lighting/: lighting_headline.cpp lighting_schedule_button.cpp
    ../../../../generated/images/src/security/: security_all_off_button.cpp security_all_on_button.cpp security_bed_room_selected.cpp security_headline.cpp security_kitchen_selected.cpp security_living_room_selected.cpp security_room1_selected.cpp security_room2_selected.cpp security_room_layout.cpp security_schedule_button.cpp
    ../../../../generated/images/src/settings/: settings_background.cpp settings_background_small.cpp slider_button.cpp
    ../../../../generated/images/src/idle/washing_ani/: WashingProgress_00.cpp WashingProgress_01.cpp WashingProgress_02.cpp WashingProgress_03.cpp WashingProgress_04.cpp WashingProgress_05.cpp WashingProgress_06.cpp WashingProgress_07.cpp WashingProgress_08.cpp WashingProgress_09.cpp WashingProgress_10.cpp WashingProgress_11.cpp WashingProgress_12.cpp WashingProgress_13.cpp WashingProgress_14.cpp WashingProgress_15.cpp WashingProgress_16.cpp WashingProgress_17.cpp WashingProgress_18.cpp WashingProgress_19.cpp WashingProgress_20.cpp
  group Startup
    ../../../: main.cpp
    ../../../../../../../../touchgfx/framework/source/platform/hal/nxp/mcu/LPC43xx/Keil/: startup_LPC43xx.s
  group TouchGFXHAL
    ../../../../../../../../touchgfx/board/Mjolner/Common/source/bsp/: Buttons.cpp LED.cpp
    ../../../../../../../../touchgfx/framework/source/platform/core/arm/cortex-m/: CortexMMCUInstrumentation.cpp
    ../../../../../../../../touchgfx/framework/source/platform/hal/nxp/mcu/LPC43xx/driver/i2c/: I2C_LPC43xx.cpp
    ../../../../../../../../touchgfx/board/Mjolner/Common/source/: GPIO.cpp
    ../../../../../../../../touchgfx/framework/source/platform/driver/touch/: ST1232TouchController.cpp
    ../../../../../../../../touchgfx/framework/source/platform/hal/nxp/mcu/LPC43xx/: NXP43XXDMA.cpp NXP43XXHAL.cpp
    ../../../../../../../../touchgfx/board/Mjolner/TouchGFXDemoBoardRev1.1-4353-7.0/source/: BoardConfiguration.cpp
  group HAL
    ../../../../../../../../touchgfx/framework/source/platform/hal/nxp/lpcspifilib/src/: spifilib_dev_common.c spifilib_fam_mac_2b_stat.c spifilib_fam_spa_3b_stat.c spifilib_fam_spa_2b_pstat.c
    ../../../../../../../../touchgfx/board/Mjolner/Common/source/bsp/: BoardInit.c KeySampler.cpp SystemInit.c SystemPinConfig.c
    ../../../../../../../../touchgfx/framework/source/platform/hal/nxp/mcu/LPC43xx/vendor/: lpc43xx_uart.c lpc43xx_ssp.c lpc43xx_timer.c lpc43xx_rgu.c lpc43xx_scu.c lpc43xx_lcd.c lpc43xx_cgu.c lpc43xx_i2c.c lpc43xx_gpio.c lpc43xx_gpdma.c lpc43xx_emc.c lpc43xx_adc.c
    ../../../../../../../../touchgfx/board/Mjolner/Common/source/vendor/lpc_core/lpc_chip/chip_18xx_43xx/: clock_18xx_43xx.c emc_18xx_43xx.c lcd_18xx_43xx.c rgu_18xx_43xx.c ssp_18xx_43xx.c
    ../../../../../../../../touchgfx/board/Mjolner/Common/source/vendor/lpc_core/lpc_ip/: emc_001.c lcd_001.c ssp_001.c
  group OS
    ../../../../../../../../touchgfx/os/FreeRTOS7.6.0/: OSWrappers.cpp
    ../../../../../../../../touchgfx/os/FreeRTOS7.6.0/Source/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../../../../../touchgfx/os/FreeRTOS7.6.0/Source/portable/MemMang/: heap_2.c
    ../../../../../../../../touchgfx/os/FreeRTOS7.6.0/Source/portable/RVDS/ARM_CM4F/: port.c
  group Lib
    ../../../../../../../../touchgfx/lib/core/cortex_m4f/Keil/: touchgfx_core.lib

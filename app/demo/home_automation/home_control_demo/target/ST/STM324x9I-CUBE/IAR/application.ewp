# IAR project application.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429NI ST STM32F429NI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ST; STM32F429xx; USE_OS_SYSTICK
  ICCARM.CCIncludePath2: ..\..\..\..\generated\images\include; ..\..\..\..\generated\fonts\include; ..\..\..\..\generated\texts\include; ..\..\..\..\platform\os; ..\..\..\..\gui\include; ..\..\..\..\target\include; ..\..\..\..\..\..\..\..\touchgfx\framework\include; ..\..\..\..\..\..\..\..\touchgfx\framework\include\platform\core\arm\cortex-m\CMSIS; ..\..\..\..\..\..\..\..\touchgfx\framework\include\platform\hal\ST\mcu\stm32f4cube; ..\..\..\..\..\..\..\..\touchgfx\framework\include\platform\hal\ST\mcu\stm32f4cube\STM32F4xx_HAL_Driver; ..\..\..\..\..\..\..\..\touchgfx\framework\include\platform\hal\ST\mcu\stm32f4cube\CMSIS; ..\..\..\..\..\..\..\..\touchgfx\board\ST\STM324x9I-CUBE\include; ..\..\..\..\..\..\..\..\touchgfx\board\ST\STM324x9I-CUBE\include\bsp; ..\..\..\..\..\..\..\..\touchgfx\board\ST\STM324x9I-CUBE\source\vendor\STM324x9I_EVAL; ..\..\..\..\..\..\..\..\touchgfx\os\FreeRTOS7.6.0\Source\include; ..\..\..\..\..\..\..\..\touchgfx\os\FreeRTOS7.6.0\Source\portable\IAR\ARM_CM4F
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\..\..\..\platform\os; ..\..\..\..\..\framework\touchgfx\platform\core\arm\cortex-m\CMSIS\include; ..\..\..\..\..\framework\touchgfx\platform\hal\ST\board\STM32429I-EVAL1\include; ..\..\..\..\..\framework\touchgfx\platform\hal\ST\board\STM32429I-EVAL1\src; ..\..\..\..\..\framework\touchgfx\platform\hal\ST\mcu\stm32f4x9\inc; ..\..\..\..\..\framework\touchgfx\platform\os\FreeRTOS7.6.0\Source\include; ..\..\..\..\..\framework\touchgfx\platform\os\FreeRTOS7.6.0\Source\portable\IAR\ARM_CM4F
  OBJCOPY.OOCOutputFile: application-eval.srec
  ILINK.IlinkOutputFile: application.out
  ILINK.IlinkIcfFile: application.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\..\..\touchgfx\lib\core\cortex_m4f\IAR\touchgfx_core.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/generated/fonts
    ../../../../generated/fonts/src/: ApplicationFontProvider.cpp Font_MavenPro_Medium_12_8bpp.cpp Font_MavenPro_Medium_14_8bpp.cpp Font_MavenPro_Medium_15_8bpp.cpp Font_MavenPro_Medium_16_8bpp.cpp Font_MavenPro_Medium_18_8bpp.cpp Font_MavenPro_Medium_20_8bpp.cpp Font_MavenPro_Medium_32_8bpp.cpp Font_MavenPro_Medium_40_8bpp.cpp Font_MavenPro_Medium_45_8bpp.cpp Font_MavenPro_Medium_75_8bpp.cpp Font_MavenPro_Regular_14_8bpp.cpp Font_MavenPro_Regular_35_8bpp.cpp FontGetters.cpp Kerning_MavenPro_Medium_12_8bpp.cpp Kerning_MavenPro_Medium_14_8bpp.cpp Kerning_MavenPro_Medium_15_8bpp.cpp Kerning_MavenPro_Medium_16_8bpp.cpp Kerning_MavenPro_Medium_18_8bpp.cpp Kerning_MavenPro_Medium_20_8bpp.cpp Kerning_MavenPro_Medium_32_8bpp.cpp Kerning_MavenPro_Medium_40_8bpp.cpp Kerning_MavenPro_Medium_45_8bpp.cpp Kerning_MavenPro_Medium_75_8bpp.cpp Kerning_MavenPro_Regular_14_8bpp.cpp Kerning_MavenPro_Regular_35_8bpp.cpp Table_MavenPro_Medium_12_8bpp.cpp Table_MavenPro_Medium_14_8bpp.cpp Table_MavenPro_Medium_15_8bpp.cpp Table_MavenPro_Medium_16_8bpp.cpp Table_MavenPro_Medium_18_8bpp.cpp Table_MavenPro_Medium_20_8bpp.cpp Table_MavenPro_Medium_32_8bpp.cpp Table_MavenPro_Medium_40_8bpp.cpp Table_MavenPro_Medium_45_8bpp.cpp Table_MavenPro_Medium_75_8bpp.cpp Table_MavenPro_Regular_14_8bpp.cpp Table_MavenPro_Regular_35_8bpp.cpp
  group Application/generated/images
    ../../../../generated/images/src/: appliances_inactive.cpp background.cpp BitmapDatabase.cpp
  group Application/generated/images/air_condition
    ../../../../generated/images/src/air_condition/: air_con_headline.cpp air_con_schedule_button.cpp air_con_schedule_button_pressed.cpp bed_room_selected.cpp jogwheel_normal.cpp jogwheel_pressed.cpp kitchen_selected.cpp living_room_selected.cpp room1_selected.cpp room2_selected.cpp room_layout.cpp
  group Application/generated/images/blinds
    ../../../../generated/images/src/blinds/: blind_selector_pressed.cpp blinds_headline.cpp blinds_schedule_button.cpp jogwheel_percentage.cpp room_layout_blinds.cpp
  group Application/generated/images/entertainment
    ../../../../generated/images/src/entertainment/: back_normal.cpp back_pressed.cpp Entertainment_headline.cpp next_normal.cpp next_pressed.cpp play_normal.cpp play_pressed.cpp shadow_large_left.cpp shadow_large_right.cpp shadow_small_left.cpp shadow_small_right.cpp top_navi.cpp
  group Application/generated/images/entertainment/covers_160
    ../../../../generated/images/src/entertainment/covers_160/: cover160_0.cpp cover160_1.cpp cover160_2.cpp cover160_3.cpp cover160_4.cpp cover160_5.cpp cover160_6.cpp cover160_7.cpp cover160_8.cpp cover160_9.cpp
  group Application/generated/images/entertainment/covers_200
    ../../../../generated/images/src/entertainment/covers_200/: cover200_0.cpp cover200_1.cpp cover200_2.cpp cover200_3.cpp cover200_4.cpp cover200_5.cpp cover200_6.cpp cover200_7.cpp cover200_8.cpp cover200_9.cpp
  group Application/generated/images/entertainment/covers_240
    ../../../../generated/images/src/entertainment/covers_240/: cover240_0.cpp cover240_1.cpp cover240_2.cpp cover240_3.cpp cover240_4.cpp cover240_5.cpp cover240_6.cpp cover240_7.cpp cover240_8.cpp cover240_9.cpp
  group Application/generated/images/idle
    ../../../../generated/images/src/idle/: air_con_top.cpp blinds_top.cpp dishwasher_tile.cpp dishwasher_tile_small.cpp dot_active.cpp dot_inactive.cpp lighting_top.cpp pause_button.cpp pause_button_pressed.cpp play_button.cpp play_button_pressed.cpp tumble_dryer_tile.cpp tumble_dryer_tile_small.cpp vert_line_buttom.cpp vert_line_top.cpp weather_bar.cpp
  group Application/generated/images/idle/covers_100
    ../../../../generated/images/src/idle/covers_100/: cover100_0.cpp cover100_1.cpp cover100_2.cpp cover100_3.cpp cover100_4.cpp cover100_5.cpp cover100_6.cpp cover100_7.cpp cover100_8.cpp cover100_9.cpp
  group Application/generated/images/idle/washing_ani
    ../../../../generated/images/src/idle/washing_ani/: WashingProgress_00.cpp WashingProgress_01.cpp WashingProgress_02.cpp WashingProgress_03.cpp WashingProgress_04.cpp WashingProgress_05.cpp WashingProgress_06.cpp WashingProgress_07.cpp WashingProgress_08.cpp WashingProgress_09.cpp WashingProgress_10.cpp WashingProgress_11.cpp WashingProgress_12.cpp WashingProgress_13.cpp WashingProgress_14.cpp WashingProgress_15.cpp WashingProgress_16.cpp WashingProgress_17.cpp WashingProgress_18.cpp WashingProgress_19.cpp WashingProgress_20.cpp
  group Application/generated/images/idle/weather_tile
    ../../../../generated/images/src/idle/weather_tile/: icon_cloudy.cpp icon_lightning.cpp icon_rain.cpp icon_rain_sun.cpp icon_sun.cpp
  group Application/generated/images/lighting
    ../../../../generated/images/src/lighting/: lighting_headline.cpp lighting_schedule_button.cpp
  group Application/generated/images/menu
    ../../../../generated/images/src/menu/: aircon_hover.cpp aircon_normal.cpp aircon_pressed.cpp appliances_hover.cpp appliances_normal.cpp appliances_pressed.cpp blinds_hover.cpp blinds_normal.cpp blinds_pressed.cpp entertainment_hover.cpp entertainment_normal.cpp entertainment_pressed.cpp lighting_hover.cpp lighting_normal.cpp lighting_pressed.cpp security_hover.cpp security_normal.cpp security_pressed.cpp settings_hover.cpp settings_normal.cpp settings_pressed.cpp
  group Application/generated/images/security
    ../../../../generated/images/src/security/: security_all_off_button.cpp security_all_on_button.cpp security_bed_room_selected.cpp security_headline.cpp security_kitchen_selected.cpp security_living_room_selected.cpp security_room1_selected.cpp security_room2_selected.cpp security_room_layout.cpp security_schedule_button.cpp
  group Application/generated/images/settings
    ../../../../generated/images/src/settings/: settings_background.cpp settings_background_small.cpp slider_button.cpp
  group Application/generated/texts
    ../../../../generated/texts/src/: LanguageGb.cpp Texts.cpp TypedTextDatabase.cpp
  group Application/gui/air_condition_screen
    ../../../../gui/src/air_condition_screen/: AirConditionPresenter.cpp AirConditionView.cpp
  group Application/gui/appliances_screen
    ../../../../gui/src/appliances_screen/: AppliancesPresenter.cpp AppliancesView.cpp
  group Application/gui/blinds_screen
    ../../../../gui/src/blinds_screen/: BlindsPresenter.cpp BlindsView.cpp
  group Application/gui/common
    ../../../../gui/src/common/: BasePresenter.cpp BlindsSelector.cpp Constants.cpp DotIndicator.cpp FadeTransition.cpp FrontendApplication.cpp JogWheel.cpp MainMenu.cpp MenuButton.cpp RoomSelector.cpp SelectionButton.cpp SwipeContainer.cpp
  group Application/gui/entertainment_screen
    ../../../../gui/src/entertainment_screen/: EntertainmentPresenter.cpp EntertainmentView.cpp
  group Application/gui/home_screen
    ../../../../gui/src/home_screen/: HomePresenter.cpp HomeView.cpp
  group Application/gui/lighting_screen
    ../../../../gui/src/lighting_screen/: LightingPresenter.cpp LightingView.cpp
  group Application/gui/model
    ../../../../gui/src/model/: AlbumManager.cpp Model.cpp WashingMachine.cpp
  group Application/gui/security_screen
    ../../../../gui/src/security_screen/: SecurityPresenter.cpp SecurityRoomSelector.cpp SecurityView.cpp
  group Application/gui/settings_screen
    ../../../../gui/src/settings_screen/: SettingsPresenter.cpp SettingsSlider.cpp SettingsView.cpp
  group Application/gui/system
    ../../../../gui/src/system/: Clock.cpp
  group Application/gui/tiles
    ../../../../gui/src/tiles/: ClockTile.cpp ImageTile.cpp MusicPlayerTile.cpp TopTile.cpp WashingMachineTile.cpp WeatherTile.cpp WeatherTileDayElement.cpp
  group Application/main
    ../../../: main.cpp
  group CubeF4/Board
    ../../../../../../../../touchgfx/board/ST/STM324x9I-CUBE/source/vendor/STM324x9I_EVAL/: stm324x9i_eval.c stm324x9i_eval_lcd.c stm324x9i_eval_nor.c stm324x9i_eval_sdram.c stm324x9i_eval_sram.c stm324x9i_eval_ts.c
    ../../../../../../../../touchgfx/board/ST/STM324x9I-CUBE/source/vendor/Components/stmpe811/: stmpe811.c
    ../../../../../../../../touchgfx/board/ST/STM324x9I-CUBE/source/vendor/Components/ts3510/: ts3510.c
    ../../../../../../../../touchgfx/board/ST/STM324x9I-CUBE/source/vendor/Components/exc7200/: exc7200.c
  group CubeF4/MCU
    ../../../../../../../../touchgfx/framework/source/platform/hal/ST/mcu/stm32f4cube/IAR/: startup_stm32f429xx.s
    ../../../../../../../../touchgfx/framework/source/platform/hal/ST/mcu/stm32f4cube/STM32F4xx_HAL_Driver/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_nor.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sdram.c stm32f4xx_hal_sram.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c
    ../../../../../../../../touchgfx/framework/source/platform/hal/ST/mcu/stm32f4cube/CMSIS/: system_stm32f4xx.c
  group OS
    ../../../../../../../../touchgfx/os/FreeRTOS7.6.0/: OSWrappers.cpp
  group OS/FreeRTOS7.6.0
    ../../../../../../../../touchgfx/os/FreeRTOS7.6.0/Source/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../../../../../touchgfx/os/FreeRTOS7.6.0/Source/portable/MemMang/: heap_2.c
  group OS/FreeRTOS7.6.0/portable
    ../../../../../../../../touchgfx/os/FreeRTOS7.6.0/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group TouchGFXPort/Board
    ../../../../../../../../touchgfx/board/ST/STM324x9I-CUBE/source/: BoardConfiguration.cpp GPIO.cpp
    ../../../../../../../../touchgfx/board/ST/STM324x9I-CUBE/source/bsp/: STM324x9IButtonController.cpp STM324x9ITouchController.cpp
  group TouchGFXPort/MCU
    ../../../../../../../../touchgfx/framework/source/platform/core/arm/cortex-m/: CortexMMCUInstrumentation.cpp
    ../../../../../../../../touchgfx/framework/source/platform/hal/ST/mcu/stm32f4cube/: STM32F4DMA.cpp STM32F4HAL.cpp

# IAR project application.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429ZI ST STM32F429ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ST; STM32F429X; STM32F429_439xx; USE_STM324x9I_EVAL; USE_STDPERIPH_DRIVER; HSE_VALUE=8000000
  ICCARM.CCIncludePath2: ..\..\..\..\generated\images\include; ..\..\..\..\generated\fonts\include; ..\..\..\..\generated\texts\include; ..\..\..\..\platform\os; ..\..\..\..\gui\include; ..\..\..\..\target\include; ..\..\..\..\..\..\..\touchgfx\framework\include; ..\..\..\..\..\..\..\touchgfx\framework\include\platform\core\arm\cortex-m\CMSIS; ..\..\..\..\..\..\..\touchgfx\framework\include\platform\hal\ST\mcu\stm32f4x9\vendor; ..\..\..\..\..\..\..\touchgfx\board\ST\STM32F429I-DISCO\include; ..\..\..\..\..\..\..\touchgfx\board\ST\STM32F429I-DISCO\include\vendor\stm32f429i_discovery; ..\..\..\..\..\..\..\touchgfx\os\FreeRTOS7.6.0\Source\include; ..\..\..\..\..\..\..\touchgfx\os\FreeRTOS7.6.0\Source\portable\IAR\ARM_CM4F
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\..\..\..\platform\os
  OBJCOPY.OOCOutputFile: application.srec
  ILINK.IlinkOutputFile: application.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\..\touchgfx\lib\core\cortex_m4f\IAR\touchgfx_core.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/generated/fonts
    ../../../../generated/fonts/src/: ApplicationFontProvider.cpp Font_Asap_Regular_12_4bpp.cpp Font_Asap_Regular_20_4bpp.cpp Font_Asap_Regular_22_4bpp.cpp Font_Asap_Regular_36_4bpp.cpp Font_RobotoCondensed_Regular_12_4bpp.cpp Font_SourceSansPro_Regular_100_4bpp.cpp Font_SourceSansPro_Regular_14_4bpp.cpp Font_SourceSansPro_Regular_18_4bpp.cpp Font_SourceSansPro_Regular_64_4bpp.cpp FontGetters.cpp Kerning_Asap_Regular_12_4bpp.cpp Kerning_Asap_Regular_20_4bpp.cpp Kerning_Asap_Regular_22_4bpp.cpp Kerning_Asap_Regular_36_4bpp.cpp Kerning_RobotoCondensed_Regular_12_4bpp.cpp Kerning_SourceSansPro_Regular_100_4bpp.cpp Kerning_SourceSansPro_Regular_14_4bpp.cpp Kerning_SourceSansPro_Regular_18_4bpp.cpp Kerning_SourceSansPro_Regular_64_4bpp.cpp Table_Asap_Regular_12_4bpp.cpp Table_Asap_Regular_20_4bpp.cpp Table_Asap_Regular_22_4bpp.cpp Table_Asap_Regular_36_4bpp.cpp Table_RobotoCondensed_Regular_12_4bpp.cpp Table_SourceSansPro_Regular_100_4bpp.cpp Table_SourceSansPro_Regular_14_4bpp.cpp Table_SourceSansPro_Regular_18_4bpp.cpp Table_SourceSansPro_Regular_64_4bpp.cpp
  group Application/generated/images
    ../../../../generated/images/src/: BitmapDatabase.cpp
  group Application/generated/images/AnimatedGraphics
    ../../../../generated/images/src/AnimatedGraphics/: animated_graphics_back_button.cpp animated_graphics_back_button_pressed.cpp light_effect_image.cpp
  group Application/generated/images/ChromArt
    ../../../../generated/images/src/ChromArt/: chrom_art_background.cpp chrom_art_clouds.cpp chrom_art_off_button.cpp chrom_art_on_button.cpp chrom_art_sun.cpp layer_button.cpp layer_button_pressed.cpp st_logo.cpp touchGFX_logo.cpp
  group Application/generated/images/HomeAutomation
    ../../../../generated/images/src/HomeAutomation/: exit_button.cpp exit_button_pressed.cpp schedule_button.cpp schedule_button_pressed.cpp temperature_adjust_button.cpp temperature_adjust_button_pressed.cpp temperature_cancel_button.cpp temperature_cancel_button_pressed.cpp temperature_jogwheel.cpp temperature_menu_item.cpp temperature_menu_item_selected.cpp temperature_menu_top_day_night.cpp temperature_menu_top_extended.cpp temperature_ok_button.cpp temperature_ok_button_inactive.cpp temperature_ok_button_pressed.cpp temperature_schedule_button_selected.cpp temperature_schedule_menu_item.cpp temperature_schedule_menu_item_selected.cpp temperature_slider.cpp temperature_slider_knop.cpp
  group Application/generated/images/LiveDataDisplay
    ../../../../generated/images/src/LiveDataDisplay/: weather_background_1.cpp weather_background_2.cpp weather_background_3.cpp weather_background_ending_1.cpp weather_dot_normal.cpp weather_dot_selected.cpp weather_small_icon_cloud.cpp weather_small_icon_shower.cpp weather_small_icon_sun.cpp weather_small_icon_sun_bigcloud.cpp weather_small_icon_thunder.cpp
  group Application/generated/images/Menu
    ../../../../generated/images/src/Menu/: background_bottom.cpp background_top.cpp menu_item_animated_graphics.cpp menu_item_chrom_art.cpp
  group Application/generated/texts
    ../../../../generated/texts/src/: LanguageGb.cpp Texts.cpp TypedTextDatabase.cpp
  group Application/gui/animated_graphics_screen
    ../../../../gui/src/animated_graphics_screen/: AnimatedGraphicsPresenter.cpp AnimatedGraphicsView.cpp BumpMapImage.cpp
  group Application/gui/chrom_art_screen
    ../../../../gui/src/chrom_art_screen/: ChromArtPresenter.cpp ChromArtView.cpp
  group Application/gui/common
    ../../../../gui/src/common/: DotIndicator.cpp FrontendApplication.cpp
  group Application/gui/home_automation_screen
    ../../../../gui/src/home_automation_screen/: HomeAutomationPresenter.cpp HomeAutomationView.cpp JogWheel.cpp TemperatureMenuItem.cpp TemperatureScheduleMenuItem.cpp TemperatureSlider.cpp
  group Application/gui/live_data_display_screen
    ../../../../gui/src/live_data_display_screen/: CityInfo.cpp LiveDataDisplayPresenter.cpp LiveDataDisplayView.cpp WeekInfo.cpp
  group Application/gui/menu_screen
    ../../../../gui/src/menu_screen/: AnimatedGraphicsTile.cpp ChromArtTile.cpp HomeAutomationTile.cpp LiveDataDisplayTile.cpp MenuPresenter.cpp MenuView.cpp
  group Application/gui/model
    ../../../../gui/src/model/: Model.cpp
  group Application/main
    ../../../: main.cpp
  group Board
    ../../../../../../../touchgfx/board/ST/STM32F429I-DISCO/source/: BoardConfiguration.cpp GPIO.cpp
  group Board/driver
    ../../../../../../../touchgfx/board/ST/STM32F429I-DISCO/source/bsp/: ResistiveTouchController.cpp
  group Board/vendor
    ../../../../../../../touchgfx/board/ST/STM32F429I-DISCO/source/vendor/: stm32f429i_discovery.c stm32f429i_discovery_i2c_ee.c stm32f429i_discovery_ioe.c stm32f429i_discovery_l3gd20.c stm32f429i_discovery_lcd.c stm32f429i_discovery_sdram.c
  group MCU
    ../../../../../../../touchgfx/framework/source/platform/core/arm/cortex-m/: CortexMMCUInstrumentation.cpp
    ../../../../../../../touchgfx/framework/source/platform/hal/ST/mcu/stm32f4x9/: STM32F4DMA.cpp STM32F4HAL.cpp
  group MCU/vendor
    ../../../../../../../touchgfx/framework/source/platform/hal/ST/mcu/stm32f4x9/IAR/: startup_stm32f429_439xx.s
    ../../../../../../../touchgfx/framework/source/platform/hal/ST/mcu/stm32f4x9/vendor/: stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c system_stm32f4xx.c
  group OS
    ../../../../../../../touchgfx/os/FreeRTOS7.6.0/: OSWrappers.cpp
  group OS/FreeRTOS760
    ../../../../../../../touchgfx/os/FreeRTOS7.6.0/Source/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../../../../touchgfx/os/FreeRTOS7.6.0/Source/portable/MemMang/: heap_2.c
    ../../../../../../../touchgfx/os/FreeRTOS7.6.0/Source/portable/IAR/ARM_CM4F/: port.c portasm.s

# Keil uVision project application.uvproj, settings and files
target Internal flash (ARM-ADS)
  device: STM32F429ZI STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: application
  c flags: Optim=4
  c define: ST STM32F429X STM32F429_439xx USE_STM324x9I_EVAL USE_STDPERIPH_DRIVER HSE_VALUE=8000000
  c include: ..\..\..\..\gui\include;..\..\..\..\target\include;..\..\..\..\platform\os;..\..\..\..\generated\fonts\include;..\..\..\..\generated\images\include;..\..\..\..\generated\texts\include;..\..\..\..\..\..\..\touchgfx\framework\include;..\..\..\..\..\..\..\touchgfx\framework\include\platform\core\arm\cortex-m\CMSIS;..\..\..\..\..\..\..\touchgfx\framework\include\platform\hal\ST\mcu\stm32f4x9\vendor;..\..\..\..\..\..\..\touchgfx\board\ST\STM32F429I-DISCO\include;..\..\..\..\..\..\..\touchgfx\board\ST\STM32F429I-DISCO\include\vendor\Common;..\..\..\..\..\..\..\touchgfx\board\ST\STM32F429I-DISCO\include\vendor\stm32f429i_discovery;..\..\..\..\..\..\..\touchgfx\os\FreeRTOS7.6.0\Source\include;..\..\..\..\..\..\..\touchgfx\os\FreeRTOS7.6.0\Source\portable\RVDS\ARM_CM4F
  asm include: ..\..\..\..\platform\os
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../../../: main.cpp
    ../../../../../../../touchgfx/framework/source/platform/hal/ST/mcu/stm32f4x9/Keil/: startup_stm32f429x.s
  group Gui
    ../../../../gui/src/animated_graphics_screen/: AnimatedGraphicsPresenter.cpp AnimatedGraphicsView.cpp BumpMapImage.cpp
    ../../../../gui/src/menu_screen/: AnimatedGraphicsTile.cpp ChromArtTile.cpp HomeAutomationTile.cpp LiveDataDisplayTile.cpp MenuPresenter.cpp MenuView.cpp
    ../../../../gui/src/chrom_art_screen/: ChromArtPresenter.cpp ChromArtView.cpp
    ../../../../gui/src/live_data_display_screen/: CityInfo.cpp LiveDataDisplayPresenter.cpp LiveDataDisplayView.cpp WeekInfo.cpp
    ../../../../gui/src/common/: DotIndicator.cpp FrontendApplication.cpp
    ../../../../gui/src/home_automation_screen/: HomeAutomationPresenter.cpp HomeAutomationView.cpp JogWheel.cpp TemperatureMenuItem.cpp TemperatureScheduleMenuItem.cpp TemperatureSlider.cpp
    ../../../../gui/src/model/: Model.cpp
  group Generated
    ../../../../generated/images/src/AnimatedGraphics/: animated_graphics_back_button.cpp animated_graphics_back_button_pressed.cpp light_effect_image.cpp
    ../../../../generated/fonts/src/: ApplicationFontProvider.cpp Font_Asap_Regular_12_4bpp.cpp Font_Asap_Regular_20_4bpp.cpp Font_Asap_Regular_22_4bpp.cpp Font_Asap_Regular_36_4bpp.cpp Font_RobotoCondensed_Regular_12_4bpp.cpp Font_SourceSansPro_Regular_100_4bpp.cpp Font_SourceSansPro_Regular_14_4bpp.cpp Font_SourceSansPro_Regular_18_4bpp.cpp Font_SourceSansPro_Regular_64_4bpp.cpp FontGetters.cpp Kerning_Asap_Regular_12_4bpp.cpp Kerning_Asap_Regular_20_4bpp.cpp Kerning_Asap_Regular_22_4bpp.cpp Kerning_Asap_Regular_36_4bpp.cpp Kerning_RobotoCondensed_Regular_12_4bpp.cpp Kerning_SourceSansPro_Regular_100_4bpp.cpp Kerning_SourceSansPro_Regular_14_4bpp.cpp Kerning_SourceSansPro_Regular_18_4bpp.cpp Kerning_SourceSansPro_Regular_64_4bpp.cpp Table_Asap_Regular_12_4bpp.cpp Table_Asap_Regular_20_4bpp.cpp Table_Asap_Regular_22_4bpp.cpp Table_Asap_Regular_36_4bpp.cpp Table_RobotoCondensed_Regular_12_4bpp.cpp Table_SourceSansPro_Regular_100_4bpp.cpp Table_SourceSansPro_Regular_14_4bpp.cpp Table_SourceSansPro_Regular_18_4bpp.cpp Table_SourceSansPro_Regular_64_4bpp.cpp
    ../../../../generated/images/src/Menu/: background_bottom.cpp background_top.cpp menu_item_animated_graphics.cpp menu_item_chrom_art.cpp
    ../../../../generated/images/src/: BitmapDatabase.cpp
    ../../../../generated/images/src/ChromArt/: chrom_art_background.cpp chrom_art_clouds.cpp chrom_art_off_button.cpp chrom_art_on_button.cpp chrom_art_sun.cpp layer_button.cpp layer_button_pressed.cpp st_logo.cpp touchGFX_logo.cpp
    ../../../../generated/images/src/HomeAutomation/: exit_button.cpp exit_button_pressed.cpp schedule_button.cpp schedule_button_pressed.cpp temperature_adjust_button.cpp temperature_adjust_button_pressed.cpp temperature_cancel_button.cpp temperature_cancel_button_pressed.cpp temperature_jogwheel.cpp temperature_menu_item.cpp temperature_menu_item_selected.cpp temperature_menu_top_day_night.cpp temperature_menu_top_extended.cpp temperature_ok_button.cpp temperature_ok_button_inactive.cpp temperature_ok_button_pressed.cpp temperature_schedule_button_selected.cpp temperature_schedule_menu_item.cpp temperature_schedule_menu_item_selected.cpp temperature_slider.cpp temperature_slider_knop.cpp
    ../../../../generated/texts/src/: LanguageGb.cpp Texts.cpp TypedTextDatabase.cpp
    ../../../../generated/images/src/LiveDataDisplay/: weather_background_1.cpp weather_background_2.cpp weather_background_3.cpp weather_background_ending_1.cpp weather_dot_normal.cpp weather_dot_selected.cpp weather_small_icon_cloud.cpp weather_small_icon_shower.cpp weather_small_icon_sun.cpp weather_small_icon_sun_bigcloud.cpp weather_small_icon_thunder.cpp
  group TouchGFXHAL
    ../../../../../../../touchgfx/framework/source/platform/core/arm/cortex-m/: CortexMMCUInstrumentation.cpp
    ../../../../../../../touchgfx/framework/source/platform/hal/ST/mcu/stm32f4x9/: STM32F4DMA.cpp STM32F4HAL.cpp
    ../../../../../../../touchgfx/board/ST/STM32F429I-DISCO/source/: BoardConfiguration.cpp GPIO.cpp
    ../../../../../../../touchgfx/board/ST/STM32F429I-DISCO/source/bsp/: ResistiveTouchController.cpp
  group HAL
    ../../../../../../../touchgfx/framework/source/platform/hal/ST/mcu/stm32f4x9/vendor/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c system_stm32f4xx.c
    ../../../../../../../touchgfx/board/ST/STM32F429I-DISCO/source/vendor/: stm32f429i_discovery.c stm32f429i_discovery_i2c_ee.c stm32f429i_discovery_ioe.c stm32f429i_discovery_lcd.c stm32f429i_discovery_sdram.c
  group OS
    ../../../../../../../touchgfx/os/FreeRTOS7.6.0/Source/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../../../../touchgfx/os/FreeRTOS7.6.0/Source/portable/MemMang/: heap_2.c
    ../../../../../../../touchgfx/os/FreeRTOS7.6.0/: OSWrappers.cpp
    ../../../../../../../touchgfx/os/FreeRTOS7.6.0/Source/portable/RVDS/ARM_CM4F/: port.c
  group Lib
    ../../../../../../../touchgfx/lib/core/cortex_m4f/Keil/: touchgfx_core.lib

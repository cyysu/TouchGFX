# IAR project application.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC4353_M4 NXP LPC4353_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M4; NXP; DISPLAY_UMSH_8253MD_3T; LPC4350
  ICCARM.CCIncludePath2: ..\..\..\..\gui\include; ..\..\..\..\target\include; ..\..\..\..\platform\os; ..\..\..\..\generated\fonts\include; ..\..\..\..\generated\images\include; ..\..\..\..\generated\texts\include; ..\..\..\..\..\..\..\touchgfx\framework\include\platform\core\arm\cortex-m\CMSIS; ..\..\..\..\..\..\..\touchgfx\framework\include; ..\..\..\..\..\..\..\touchgfx\board\Mjolner\Common\include\bsp; ..\..\..\..\..\..\..\touchgfx\board\Mjolner\Common\include\vendor; ..\..\..\..\..\..\..\touchgfx\board\Mjolner\Common\source\vendor; ..\..\..\..\..\..\..\touchgfx\board\Mjolner\Common\source\vendor\lpc_core\lpc_ip; ..\..\..\..\..\..\..\touchgfx\board\Mjolner\Common\source\vendor\lpc_core\lpc_chip\chip_18xx_43xx; ..\..\..\..\..\..\..\touchgfx\os\FreeRTOS7.6.0\Source\include; ..\..\..\..\..\..\..\touchgfx\os\FreeRTOS7.6.0\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\..\..\touchgfx\framework\include\platform\hal\nxp\mcu\LPC43xx; ..\..\..\..\..\..\..\touchgfx\framework\include\platform\hal\nxp\mcu\LPC43xx\vendor; ..\..\..\..\..\..\..\touchgfx\framework\source\platform\hal\nxp\lpcspifilib\inc; ..\..\..\..\..\..\..\touchgfx\framework\source\platform\hal\nxp\lpcspifilib\src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\..\..\..\platform\os
  OBJCOPY.OOCOutputFile: application.hex
  ILINK.IlinkOutputFile: application.out
  ILINK.IlinkIcfFile: application.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\..\touchgfx\lib\core\cortex_m4f\IAR\touchgfx_core.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/generated/fonts
    ../../../../generated/fonts/src/: ApplicationFontProvider.cpp Font_Asap_Regular_15_4bpp.cpp Font_Asap_Regular_20_4bpp.cpp Font_Asap_Regular_22_4bpp.cpp Font_Asap_Regular_36_4bpp.cpp Font_RobotoCondensed_Regular_12_4bpp.cpp Font_RobotoCondensed_Regular_14_4bpp.cpp Font_RobotoCondensed_Regular_26_4bpp.cpp Font_SourceSansPro_Regular_100_4bpp.cpp Font_SourceSansPro_Regular_14_4bpp.cpp Font_SourceSansPro_Regular_16_4bpp.cpp Font_SourceSansPro_Regular_18_4bpp.cpp Font_SourceSansPro_Regular_26_4bpp.cpp FontGetters.cpp Kerning_Asap_Regular_15_4bpp.cpp Kerning_Asap_Regular_20_4bpp.cpp Kerning_Asap_Regular_22_4bpp.cpp Kerning_Asap_Regular_36_4bpp.cpp Kerning_RobotoCondensed_Regular_12_4bpp.cpp Kerning_RobotoCondensed_Regular_14_4bpp.cpp Kerning_RobotoCondensed_Regular_26_4bpp.cpp Kerning_SourceSansPro_Regular_100_4bpp.cpp Kerning_SourceSansPro_Regular_14_4bpp.cpp Kerning_SourceSansPro_Regular_16_4bpp.cpp Kerning_SourceSansPro_Regular_18_4bpp.cpp Kerning_SourceSansPro_Regular_26_4bpp.cpp Table_Asap_Regular_15_4bpp.cpp Table_Asap_Regular_20_4bpp.cpp Table_Asap_Regular_22_4bpp.cpp Table_Asap_Regular_36_4bpp.cpp Table_RobotoCondensed_Regular_12_4bpp.cpp Table_RobotoCondensed_Regular_14_4bpp.cpp Table_RobotoCondensed_Regular_26_4bpp.cpp Table_SourceSansPro_Regular_100_4bpp.cpp Table_SourceSansPro_Regular_14_4bpp.cpp Table_SourceSansPro_Regular_16_4bpp.cpp Table_SourceSansPro_Regular_18_4bpp.cpp Table_SourceSansPro_Regular_26_4bpp.cpp
  group Application/generated/images
    ../../../../generated/images/src/: Back_menu_shadow.cpp BitmapDatabase.cpp demo_mcu_load_background.cpp
  group Application/generated/images/AnimatedGraphics
    ../../../../generated/images/src/AnimatedGraphics/: light_effect_image.cpp light_effect_image_test.cpp
  group Application/generated/images/ChromArt
    ../../../../generated/images/src/ChromArt/: chrom_art_background_left.cpp chrom_art_background_right.cpp chrom_art_clouds.cpp chrom_art_off_button.cpp chrom_art_on_button.cpp chrom_art_sun.cpp layer_button.cpp layer_button_pressed.cpp st_logo.cpp touchGFX_logo.cpp
  group Application/generated/images/Clock
    ../../../../generated/images/src/Clock/: center_dot.cpp clock_background.cpp
  group Application/generated/images/DataVisualization
    ../../../../generated/images/src/DataVisualization/: graph_12hours_back.cpp graph_12hours_tab.cpp graph_12hours_tab_pressed.cpp graph_6hours_back_bottom.cpp graph_6hours_back_top.cpp graph_6hours_green_bar.cpp graph_6hours_pink_bar.cpp graph_6hours_tab.cpp graph_6hours_tab_pressed.cpp graph_7days_back.cpp graph_7days_tab.cpp graph_7days_tab_pressed.cpp graph_slider_dot.cpp graph_slider_line.cpp graph_slider_top.cpp graph_tab_back.cpp
  group Application/generated/images/FlowPresentation
    ../../../../generated/images/src/FlowPresentation/: next_button.cpp next_button_pressed.cpp parallax_background.cpp parallax_foreground_0.cpp parallax_foreground_1.cpp parallax_foreground_2.cpp parallax_foreground_3.cpp previous_button.cpp previous_button_pressed.cpp
  group Application/generated/images/Menu
    ../../../../generated/images/src/Menu/: demo_back_button.cpp demo_back_button_pressed.cpp menu_demo_button.cpp menu_demo_button_pressed.cpp menu_demo_in_progress.cpp menu_description_field_background.cpp menu_item_about_touchgfx_inactive.cpp menu_item_about_touchgfx_normal.cpp menu_item_about_touchgfx_pressed.cpp menu_item_animated_graphics_inactive.cpp menu_item_animated_graphics_normal.cpp menu_item_animated_graphics_pressed.cpp menu_item_calender_inactive.cpp menu_item_calender_normal.cpp menu_item_calender_pressed.cpp menu_item_chrom_art_inactive.cpp menu_item_chrom_art_normal.cpp menu_item_chrom_art_pressed.cpp menu_item_clock_inactive.cpp menu_item_clock_normal.cpp menu_item_clock_pressed.cpp menu_item_data_visualization_inactive.cpp menu_item_data_visualization_normal.cpp menu_item_data_visualization_pressed.cpp menu_item_flow_presentation_inactive.cpp menu_item_flow_presentation_normal.cpp menu_item_flow_presentation_pressed.cpp menu_item_home_automation_inactive.cpp menu_item_home_automation_normal.cpp menu_item_home_automation_pressed.cpp menu_item_list_navigation_inactive.cpp menu_item_list_navigation_normal.cpp menu_item_list_navigation_pressed.cpp menu_item_live_data_display_inactive.cpp menu_item_live_data_display_normal.cpp menu_item_live_data_display_pressed.cpp menu_item_nxp_and_touchgfx_inactive.cpp menu_item_nxp_and_touchgfx_normal.cpp menu_item_nxp_and_touchgfx_pressed.cpp menu_item_settings_inactive.cpp menu_item_settings_normal.cpp menu_item_settings_pressed.cpp menu_logo.cpp
  group Application/generated/images/MusicPlayer
    ../../../../generated/images/src/MusicPlayer/: music_player_album_beatles.cpp music_player_album_beyonce.cpp music_player_album_madonna.cpp music_player_album_metallica.cpp music_player_album_mj.cpp music_player_album_rihanna.cpp music_player_background.cpp music_player_button_jump_to_start.cpp music_player_button_jump_to_start_pressed.cpp music_player_button_next.cpp music_player_button_next_pressed.cpp music_player_button_play.cpp music_player_button_play_pressed.cpp music_player_button_stop.cpp music_player_button_stop_pressed.cpp music_player_pickup.cpp music_player_sound_level_0.cpp music_player_sound_level_1.cpp music_player_sound_level_2.cpp music_player_sound_level_3.cpp music_player_sound_level_4.cpp music_player_volume_slider.cpp music_player_volume_slider_active.cpp music_player_volume_slider_button.cpp track_play_button.cpp track_play_button_pressed.cpp
  group Application/generated/images/MusicPlayer/AlbumSelector
    ../../../../generated/images/src/MusicPlayer/AlbumSelector/: music_player_album_row.cpp music_player_album_row_album_beatles.cpp music_player_album_row_album_beyonce.cpp music_player_album_row_album_madonna.cpp music_player_album_row_album_metallica.cpp music_player_album_row_album_mj.cpp music_player_album_row_album_rihanna.cpp music_player_album_row_button.cpp music_player_album_row_button_pressed.cpp music_player_album_row_selected.cpp music_player_album_row_selected_button.cpp music_player_album_selector_headline.cpp music_player_album_selector_headline_button.cpp music_player_track_selector_background.cpp music_player_track_selector_beatles.cpp music_player_track_selector_beyonce.cpp music_player_track_selector_headline.cpp music_player_track_selector_headline_button.cpp music_player_track_selector_madonna.cpp music_player_track_selector_metallica.cpp music_player_track_selector_mj.cpp music_player_track_selector_rihanna.cpp music_player_track_selector_row.cpp music_player_track_selector_row_last_element.cpp music_player_track_selector_row_selected.cpp
  group Application/generated/images/MusicPlayer/RecordAnimations/Beatles
    ../../../../generated/images/src/MusicPlayer/RecordAnimations/Beatles/: record_beatles_00000.cpp record_beatles_00001.cpp record_beatles_00002.cpp record_beatles_00003.cpp record_beatles_00004.cpp record_beatles_00005.cpp record_beatles_00006.cpp record_beatles_00007.cpp record_beatles_00008.cpp record_beatles_00009.cpp record_beatles_00010.cpp record_beatles_00011.cpp record_beatles_00012.cpp record_beatles_00013.cpp record_beatles_00014.cpp record_beatles_00015.cpp record_beatles_00016.cpp record_beatles_00017.cpp record_beatles_00018.cpp record_beatles_00019.cpp
  group Application/generated/images/MusicPlayer/RecordAnimations/Beyonce
    ../../../../generated/images/src/MusicPlayer/RecordAnimations/Beyonce/: record_beyonce_00000.cpp record_beyonce_00001.cpp record_beyonce_00002.cpp record_beyonce_00003.cpp record_beyonce_00004.cpp record_beyonce_00005.cpp record_beyonce_00006.cpp record_beyonce_00007.cpp record_beyonce_00008.cpp record_beyonce_00009.cpp record_beyonce_00010.cpp record_beyonce_00011.cpp record_beyonce_00012.cpp record_beyonce_00013.cpp record_beyonce_00014.cpp record_beyonce_00015.cpp record_beyonce_00016.cpp record_beyonce_00017.cpp record_beyonce_00018.cpp record_beyonce_00019.cpp
  group Application/generated/images/MusicPlayer/RecordAnimations/Madonna
    ../../../../generated/images/src/MusicPlayer/RecordAnimations/Madonna/: record_madonna_00000.cpp record_madonna_00001.cpp record_madonna_00002.cpp record_madonna_00003.cpp record_madonna_00004.cpp record_madonna_00005.cpp record_madonna_00006.cpp record_madonna_00007.cpp record_madonna_00008.cpp record_madonna_00009.cpp record_madonna_00010.cpp record_madonna_00011.cpp record_madonna_00012.cpp record_madonna_00013.cpp record_madonna_00014.cpp record_madonna_00015.cpp record_madonna_00016.cpp record_madonna_00017.cpp record_madonna_00018.cpp record_madonna_00019.cpp
  group Application/generated/images/MusicPlayer/RecordAnimations/Metallica
    ../../../../generated/images/src/MusicPlayer/RecordAnimations/Metallica/: record_metallica_00000.cpp record_metallica_00001.cpp record_metallica_00002.cpp record_metallica_00003.cpp record_metallica_00004.cpp record_metallica_00005.cpp record_metallica_00006.cpp record_metallica_00007.cpp record_metallica_00008.cpp record_metallica_00009.cpp record_metallica_00010.cpp record_metallica_00011.cpp record_metallica_00012.cpp record_metallica_00013.cpp record_metallica_00014.cpp record_metallica_00015.cpp record_metallica_00016.cpp record_metallica_00017.cpp record_metallica_00018.cpp record_metallica_00019.cpp
  group Application/generated/images/MusicPlayer/RecordAnimations/MJ
    ../../../../generated/images/src/MusicPlayer/RecordAnimations/MJ/: record_mj_00000.cpp record_mj_00001.cpp record_mj_00002.cpp record_mj_00003.cpp record_mj_00004.cpp record_mj_00005.cpp record_mj_00006.cpp record_mj_00007.cpp record_mj_00008.cpp record_mj_00009.cpp record_mj_00010.cpp record_mj_00011.cpp record_mj_00012.cpp record_mj_00013.cpp record_mj_00014.cpp record_mj_00015.cpp record_mj_00016.cpp record_mj_00017.cpp record_mj_00018.cpp record_mj_00019.cpp
  group Application/generated/images/MusicPlayer/RecordAnimations/Rihanna
    ../../../../generated/images/src/MusicPlayer/RecordAnimations/Rihanna/: record_rihanna_00000.cpp record_rihanna_00001.cpp record_rihanna_00002.cpp record_rihanna_00003.cpp record_rihanna_00004.cpp record_rihanna_00005.cpp record_rihanna_00006.cpp record_rihanna_00007.cpp record_rihanna_00008.cpp record_rihanna_00009.cpp record_rihanna_00010.cpp record_rihanna_00011.cpp record_rihanna_00012.cpp record_rihanna_00013.cpp record_rihanna_00014.cpp record_rihanna_00015.cpp record_rihanna_00016.cpp record_rihanna_00017.cpp record_rihanna_00018.cpp record_rihanna_00019.cpp
  group Application/generated/images/NXPAndTouchGFX
    ../../../../generated/images/src/NXPAndTouchGFX/: nxp_button_left.cpp nxp_button_left_pressed.cpp nxp_button_middle_gradient.cpp nxp_button_right.cpp nxp_button_right_pressed.cpp nxp_dot_normal.cpp nxp_dot_pressed.cpp nxp_embedded_image.cpp nxp_embedded_text.cpp nxp_embedded_text_top.cpp nxp_fdi_image.cpp nxp_fdi_text.cpp nxp_fdi_text_top.cpp nxp_image_box_background.cpp nxp_image_gradient.cpp nxp_keil_image.cpp nxp_keil_text.cpp nxp_keil_text_top.cpp nxp_text_top_background.cpp nxp_textbox_background.cpp nxp_textbox_gradient.cpp nxp_touchgfx_image.cpp nxp_touchgfx_text.cpp nxp_touchgfx_text_top.cpp
  group Application/generated/images/TemperatureControl
    ../../../../generated/images/src/TemperatureControl/: temperature_auto_button.cpp temperature_auto_button_pressed.cpp temperature_jogwheel.cpp temperature_jogwheel_pressed.cpp temperature_menu_bottom.cpp temperature_menu_item.cpp temperature_menu_item_selected.cpp temperature_menu_top.cpp temperature_menu_top_extended.cpp temperature_off_button.cpp temperature_off_button_pressed.cpp temperature_ok_button.cpp temperature_ok_button_inactive.cpp temperature_ok_button_pressed.cpp temperature_schedule_button.cpp temperature_schedule_button_pressed.cpp temperature_schedule_button_selected.cpp temperature_slider.cpp temperature_slider_knop.cpp
  group Application/generated/images/Weather
    ../../../../generated/images/src/Weather/: weather_background_1.cpp weather_background_2.cpp weather_background_3.cpp weather_background_4.cpp weather_background_ending_1.cpp weather_background_ending_4.cpp weather_big_icon_clouds.cpp weather_big_icon_sun.cpp weather_big_icon_sun_clouds.cpp weather_big_icon_thunder.cpp weather_dot_normal.cpp weather_dot_selected.cpp weather_small_icon_cloud.cpp weather_small_icon_shower.cpp weather_small_icon_sun.cpp weather_small_icon_sun_bigcloud.cpp weather_small_icon_thunder.cpp
  group Application/generated/texts
    ../../../../generated/texts/src/: LanguageGb.cpp Texts.cpp TypedTextDatabase.cpp
  group Application/gui/animated_graphics_screen
    ../../../../gui/src/animated_graphics_screen/: AnimatedGraphicsPresenter.cpp AnimatedGraphicsView.cpp BumpMapImage.cpp
  group Application/gui/chrom_art_screen
    ../../../../gui/src/chrom_art_screen/: ChromArtPresenter.cpp ChromArtView.cpp
  group Application/gui/clock_screen
    ../../../../gui/src/clock_screen/: ClockPresenter.cpp ClockView.cpp
  group Application/gui/common
    ../../../../gui/src/common/: DemoPresenter.cpp DotIndicator.cpp FrontendApplication.cpp ImageMenu.cpp McuLoadSlider.cpp
  group Application/gui/data_visualization_screen
    ../../../../gui/src/data_visualization_screen/: BarContainer.cpp DataVisualizationPresenter.cpp DataVisualizationView.cpp Graph.cpp InteractiveGraph.cpp
  group Application/gui/flow_presentation_screen
    ../../../../gui/src/flow_presentation_screen/: FlowPresentationPresenter.cpp FlowPresentationView.cpp
  group Application/gui/home_automation_screen
    ../../../../gui/src/home_automation_screen/: HomeAutomationPresenter.cpp HomeAutomationView.cpp JogWheel.cpp TemperatureMenuItem.cpp TemperatureScheduleMenuItem.cpp TemperatureSlider.cpp
  group Application/gui/list_navigation_screen
    ../../../../gui/src/list_navigation_screen/: AlbumManager.cpp AlbumRow.cpp AlbumSelector.cpp ListNavigationPresenter.cpp ListNavigationView.cpp TrackRow.cpp TrackSelector.cpp VolumeSlider.cpp
  group Application/gui/live_data_display_screen
    ../../../../gui/src/live_data_display_screen/: CityInfo.cpp LiveDataDisplayPresenter.cpp LiveDataDisplayView.cpp WeekInfo.cpp
  group Application/gui/main_screen
    ../../../../gui/src/main_screen/: MainPresenter.cpp MainView.cpp
  group Application/gui/model
    ../../../../gui/src/model/: Model.cpp
  group Application/gui/nxp_and_touchgfx_screen
    ../../../../gui/src/nxp_and_touchgfx_screen/: NXPAndTouchGFXPresenter.cpp NXPAndTouchGFXView.cpp
  group Application/main
    ../../../: main.cpp
  group Board/TouchGFXDemoBoardRev1.1-4353-4.3
    ../../../../../../../touchgfx/board/Mjolner/TouchGFXDemoBoardRev1.1-4353-4.3/source/: BoardConfiguration.cpp
    ../../../../../../../touchgfx/board/Mjolner/Common/source/: GPIO.cpp
  group Board/TouchGFXDemoBoardRev1.1-4353-4.3/Common/BSP
    ../../../../../../../touchgfx/board/Mjolner/Common/source/bsp/: Buttons.cpp LED.cpp
  group Board/TouchGFXDemoBoardRev1.1-4353-4.3/Common/driver
    ../../../../../../../touchgfx/framework/source/platform/hal/nxp/mcu/LPC43xx/driver/i2c/: I2C_LPC43xx.cpp
    ../../../../../../../touchgfx/board/Mjolner/Common/source/bsp/: KeySampler.cpp
    ../../../../../../../touchgfx/framework/source/platform/driver/touch/: ST1232TouchController.cpp
  group Board/TouchGFXDemoBoardRev1.1-4353-4.3/Common/init
    ../../../../../../../touchgfx/board/Mjolner/Common/source/bsp/: BoardInit.c SystemPinConfig.c
  group Board/TouchGFXDemoBoardRev1.1-4353-4.3/Common/Vendor/lpc_open
    ../../../../../../../touchgfx/board/Mjolner/Common/source/vendor/lpc_core/lpc_chip/chip_18xx_43xx/: clock_18xx_43xx.c emc_18xx_43xx.c lcd_18xx_43xx.c rgu_18xx_43xx.c ssp_18xx_43xx.c
    ../../../../../../../touchgfx/board/Mjolner/Common/source/vendor/lpc_core/lpc_ip/: emc_001.c lcd_001.c ssp_001.c
  group Board/TouchGFXDemoBoardRev1.1-4353-4.3/init
    ../../../../../../../touchgfx/board/Mjolner/TouchGFXDemoBoardRev1.1-4350-4.3/source/bsp/: SystemInit.c SystemInitRAM.c
  group MCU
    ../../../../../../../touchgfx/framework/source/platform/core/arm/cortex-m/: CortexMMCUInstrumentation.cpp
  group MCU/LPC4353
    ../../../../../../../touchgfx/framework/source/platform/hal/nxp/mcu/LPC43xx/: NXP43XXDMA.cpp NXP43XXHAL.cpp
  group MCU/LPC4353/vendor
    ../../../../../../../touchgfx/framework/source/platform/hal/nxp/mcu/LPC43xx/vendor/: lpc43xx_adc.c lpc43xx_cgu.c lpc43xx_emc.c lpc43xx_gpdma.c lpc43xx_gpio.c lpc43xx_i2c.c lpc43xx_lcd.c lpc43xx_rgu.c lpc43xx_scu.c lpc43xx_ssp.c lpc43xx_timer.c lpc43xx_uart.c
    ../../../../../../../touchgfx/framework/source/platform/hal/nxp/mcu/LPC43xx/IAR/: startup_LPC43xx.s
  group MCU/SPIFI
    ../../../../../../../touchgfx/framework/source/platform/hal/nxp/lpcspifilib/src/: spifilib_dev_common.c spifilib_fam_mac_2b_stat.c spifilib_fam_spa_2b_pstat.c spifilib_fam_spa_3b_stat.c
  group OS
    ../../../../../../../touchgfx/os/FreeRTOS7.6.0/: OSWrappers.cpp
  group OS/FreeRTOS7.6.0
    ../../../../../../../touchgfx/os/FreeRTOS7.6.0/Source/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../../../../touchgfx/os/FreeRTOS7.6.0/Source/portable/MemMang/: heap_2.c
  group OS/FreeRTOS7.6.0/portable
    ../../../../../../../touchgfx/os/FreeRTOS7.6.0/Source/portable/IAR/ARM_CM4F/: port.c portasm.s

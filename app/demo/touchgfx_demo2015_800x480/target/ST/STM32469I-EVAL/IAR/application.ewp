# IAR project application.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429NI ST STM32F429NI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ST; USE_STDPERIPH_DRIVER; STM32F469xx; USE_STM32469I_EVAL; USE_FLOATING_POINT; USE_OS_SYSTICK; USE_IOEXPANDER
  ICCARM.CCIncludePath2: ..\..\..\..\generated\images\include; ..\..\..\..\generated\fonts\include; ..\..\..\..\generated\texts\include; ..\..\..\..\platform\os; ..\..\..\..\gui\include; ..\..\..\..\target\include; ..\..\..\..\..\..\..\touchgfx\framework\include; ..\..\..\..\..\..\..\touchgfx\framework\include\platform\core\arm\cortex-m\CMSIS; ..\..\..\..\..\..\..\touchgfx\framework\include\platform\hal\ST\mcu\stm32f4cube; ..\..\..\..\..\..\..\touchgfx\framework\include\platform\hal\ST\mcu\stm32f4cube\STM32F4xx_HAL_Driver; ..\..\..\..\..\..\..\touchgfx\framework\include\platform\hal\ST\mcu\stm32f4cube\CMSIS; ..\..\..\..\..\..\..\touchgfx\board\ST\STM32469I-EVAL\include; ..\..\..\..\..\..\..\touchgfx\board\ST\STM32469I-EVAL\include\bsp; ..\..\..\..\..\..\..\touchgfx\board\ST\STM32469I-EVAL\source\vendor\STM32469I_EVAL; ..\..\..\..\..\..\..\touchgfx\os\FreeRTOS7.6.0\Source\include; ..\..\..\..\..\..\..\touchgfx\os\FreeRTOS7.6.0\Source\portable\IAR\ARM_CM4F
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\..\..\..\platform\os; ..\..\..\..\..\framework\touchgfx\platform\core\arm\cortex-m\CMSIS\include; ..\..\..\..\..\framework\touchgfx\platform\hal\ST\board\STM32429I-EVAL1\include; ..\..\..\..\..\framework\touchgfx\platform\hal\ST\board\STM32429I-EVAL1\src; ..\..\..\..\..\framework\touchgfx\platform\hal\ST\mcu\stm32f4x9\inc; ..\..\..\..\..\framework\touchgfx\platform\os\FreeRTOS7.6.0\Source\include; ..\..\..\..\..\framework\touchgfx\platform\os\FreeRTOS7.6.0\Source\portable\IAR\ARM_CM4F
  OBJCOPY.OOCOutputFile: application.hex
  ILINK.IlinkOutputFile: application.out
  ILINK.IlinkIcfFile: application.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\..\touchgfx\lib\core\cortex_m4f\IAR\touchgfx_core.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/generated/fonts
    ../../../../generated/fonts/src/: ApplicationFontProvider.cpp Font_Asap_Bold_otf_16_4bpp.cpp Font_Asap_Bold_otf_20_4bpp.cpp Font_Asap_Bold_otf_26_4bpp.cpp Font_Asap_Bold_otf_27_4bpp.cpp Font_Asap_Bold_otf_50_4bpp.cpp Font_Asap_Regular_13_4bpp.cpp Font_Asap_Regular_17_4bpp.cpp Font_Asap_Regular_18_4bpp.cpp Font_Asap_Regular_20_4bpp.cpp Font_Asap_Regular_21_4bpp.cpp Font_Asap_Regular_22_4bpp.cpp Font_Asap_Regular_28_4bpp.cpp Font_Asap_Regular_42_4bpp.cpp Font_ipaexg_17_4bpp.cpp Font_ipaexg_22_4bpp.cpp Font_NotoSans_Regular_17_4bpp.cpp Font_NotoSans_Regular_22_4bpp.cpp FontGetters.cpp Kerning_Asap_Bold_otf_16_4bpp.cpp Kerning_Asap_Bold_otf_20_4bpp.cpp Kerning_Asap_Bold_otf_26_4bpp.cpp Kerning_Asap_Bold_otf_27_4bpp.cpp Kerning_Asap_Bold_otf_50_4bpp.cpp Kerning_Asap_Regular_13_4bpp.cpp Kerning_Asap_Regular_17_4bpp.cpp Kerning_Asap_Regular_18_4bpp.cpp Kerning_Asap_Regular_20_4bpp.cpp Kerning_Asap_Regular_21_4bpp.cpp Kerning_Asap_Regular_22_4bpp.cpp Kerning_Asap_Regular_28_4bpp.cpp Kerning_Asap_Regular_42_4bpp.cpp Kerning_ipaexg_17_4bpp.cpp Kerning_ipaexg_22_4bpp.cpp Kerning_NotoSans_Regular_17_4bpp.cpp Kerning_NotoSans_Regular_22_4bpp.cpp Table_Asap_Bold_otf_16_4bpp.cpp Table_Asap_Bold_otf_20_4bpp.cpp Table_Asap_Bold_otf_26_4bpp.cpp Table_Asap_Bold_otf_27_4bpp.cpp Table_Asap_Bold_otf_50_4bpp.cpp Table_Asap_Regular_13_4bpp.cpp Table_Asap_Regular_17_4bpp.cpp Table_Asap_Regular_18_4bpp.cpp Table_Asap_Regular_20_4bpp.cpp Table_Asap_Regular_21_4bpp.cpp Table_Asap_Regular_22_4bpp.cpp Table_Asap_Regular_28_4bpp.cpp Table_Asap_Regular_42_4bpp.cpp Table_ipaexg_17_4bpp.cpp Table_ipaexg_22_4bpp.cpp Table_NotoSans_Regular_17_4bpp.cpp Table_NotoSans_Regular_22_4bpp.cpp
  group Application/generated/images
    ../../../../generated/images/src/: BitmapDatabase.cpp
  group Application/generated/images/AnimatingButtonsMenu
    ../../../../generated/images/src/AnimatingButtonsMenu/: Animating_buttons_background.cpp Animating_buttons_full_table_shadow_bottom.cpp Animating_buttons_full_table_shadow_left.cpp Animating_buttons_full_table_shadow_right.cpp animating_buttons_menu_icons_2048_tiny.cpp animating_buttons_menu_icons_game_2d_tiny.cpp animating_buttons_menu_icons_gauge_tiny.cpp animating_buttons_menu_icons_graph_tiny.cpp animating_buttons_menu_icons_poster_tiny.cpp Animating_buttons_table_element_shadow.cpp
  group Application/generated/images/CarouselMenu
    ../../../../generated/images/src/CarouselMenu/: carousel_background.cpp carousel_menu_icons_2048_large.cpp carousel_menu_icons_2048_medium.cpp carousel_menu_icons_2048_small.cpp carousel_menu_icons_game_2d_large.cpp carousel_menu_icons_game_2d_medium.cpp carousel_menu_icons_game_2d_small.cpp carousel_menu_icons_gauge_large.cpp carousel_menu_icons_gauge_medium.cpp carousel_menu_icons_gauge_small.cpp carousel_menu_icons_graph_large.cpp carousel_menu_icons_graph_medium.cpp carousel_menu_icons_graph_small.cpp carousel_menu_icons_poster_large.cpp carousel_menu_icons_poster_medium.cpp carousel_menu_icons_poster_small.cpp menu_toggle_button.cpp menu_toggle_button_pressed.cpp st_menu_button.cpp st_menu_button_pressed.cpp
  group Application/generated/images/CustomControls
    ../../../../generated/images/src/CustomControls/: control_center_button.cpp control_center_button_pressed.cpp control_color_wheel.cpp control_menu_button.cpp control_menu_button_pressed.cpp control_menu_icon_datepicker_large.cpp control_menu_icon_datepicker_small.cpp control_menu_icon_gauge_large.cpp control_menu_icon_gauge_small.cpp control_menu_icon_percentage_large.cpp control_menu_icon_percentage_small.cpp control_menu_icon_three_way_large.cpp control_menu_icon_three_way_small.cpp control_menu_shadow_bottom.cpp control_menu_shadow_top.cpp controls_background.cpp controls_menu_background.cpp controls_three_way_small_circle.cpp controls_wheel_background.cpp datepicker_bottom_shadow_overlay.cpp datepicker_glass_overlay.cpp datepicker_main_background.cpp datepicker_top_shadow_overlay.cpp gauge_background.cpp gauge_needle_pin.cpp small_circle_bin_icon_active.cpp small_circle_bin_icon_inactive.cpp small_circle_folder_icon_active.cpp small_circle_folder_icon_inactive.cpp small_circle_papers_icon_active.cpp small_circle_papers_icon_inactive.cpp
  group Application/generated/images/Game2048
    ../../../../generated/images/src/Game2048/: auto_play_button.cpp auto_play_button_pressed.cpp game_2048_background.cpp game_2048_dot_off.cpp game_2048_dot_on.cpp game_2048_game_over.cpp game_2048_menu_button.cpp game_2048_menu_button_pressed.cpp game_2048_you_win.cpp how_to_play_00.cpp how_to_play_01.cpp how_to_play_02.cpp how_to_play_background.cpp how_to_play_button.cpp how_to_play_button_pressed.cpp how_to_play_close_button.cpp new_game_button.cpp new_game_button_pressed.cpp tile_0002.cpp tile_0004.cpp tile_0008.cpp tile_0016.cpp tile_0032.cpp tile_0064.cpp tile_0128.cpp tile_0256.cpp tile_0512.cpp tile_1024.cpp tile_2048.cpp
  group Application/generated/images/Game2D
    ../../../../generated/images/src/Game2D/: collectible_item_00.cpp collectible_item_01.cpp collectible_item_02.cpp collectible_item_03.cpp collectible_item_04.cpp collectible_item_05.cpp collectible_item_06.cpp collectible_item_07.cpp collectible_item_08.cpp collectible_item_09.cpp game2d_background.cpp game2d_fly_button.cpp game2d_fly_button_pressed.cpp game2d_ground.cpp game2d_menu_button.cpp game2d_menu_button_pressed.cpp game2d_st_button_off.cpp game2d_st_button_off_pressed.cpp game2d_st_button_on.cpp game2d_st_button_pressed.cpp game2d_topLeaves.cpp game2d_TreeTops.cpp game_2d_frame_background.cpp sphere1.cpp sprite_00.cpp sprite_01.cpp sprite_02.cpp sprite_03.cpp sprite_04.cpp sprite_05.cpp sprite_06.cpp sprite_07.cpp sprite_08.cpp sprite_09.cpp
  group Application/generated/images/Graphs
    ../../../../generated/images/src/Graphs/: blue_area_button_active.cpp blue_area_button_inactive.cpp blue_dots_button_active.cpp blue_dots_button_inactive.cpp blue_line_button_active.cpp blue_line_button_inactive.cpp graph_background_bottom.cpp graph_background_top.cpp graph_menu_button.cpp graph_menu_button_pressed.cpp graph_toggle_button_active.cpp graph_toggle_button_inactive.cpp green_area_button_active.cpp green_area_button_inactive.cpp green_dots_button_active.cpp green_dots_button_inactive.cpp green_line_button_active.cpp green_line_button_inactive.cpp half_circle_toggle_button_active.cpp half_circle_toggle_button_inactive.cpp new_graph.cpp new_graph_pressed.cpp new_pie_chart.cpp new_pie_chart_pressed.cpp pie_chart_gradient_map.cpp pie_chart_legend_blue.cpp pie_chart_legend_blue_active.cpp pie_chart_legend_green.cpp pie_chart_legend_green_active.cpp pie_chart_legend_orange.cpp pie_chart_legend_orange_active.cpp pie_chart_legend_purple.cpp pie_chart_legend_purple_active.cpp pie_chart_legend_red.cpp pie_chart_legend_red_active.cpp pie_chart_legend_yellow.cpp pie_chart_legend_yellow_active.cpp pie_toggle_button_active.cpp pie_toggle_button_inactive.cpp
  group Application/generated/images/ProductPresenter
    ../../../../generated/images/src/ProductPresenter/: alpha_ball_blue.cpp alpha_ball_green.cpp alpha_ball_red.cpp flag_dnk_active.cpp flag_dnk_inactive.cpp flag_gbr_active.cpp flag_gbr_inactive.cpp flag_jpn_active.cpp flag_jpn_inactive.cpp flag_nld_active.cpp flag_nld_inactive.cpp flag_ukr_active.cpp flag_ukr_inactive.cpp menu_button.cpp menu_button_active.cpp paper_overlay.cpp poster_animation_button.cpp poster_animation_button_arrow_00.cpp poster_animation_button_arrow_01.cpp poster_animation_button_arrow_02.cpp poster_animation_button_arrow_03.cpp poster_animation_button_arrow_04.cpp poster_animation_button_arrow_05.cpp poster_animation_button_arrow_06.cpp poster_gradient_overlay.cpp poster_image_00.cpp poster_image_01.cpp poster_image_02.cpp poster_shadow_bottom.cpp poster_shadow_left.cpp poster_shadow_right.cpp poster_shadow_top.cpp product_presenter_background.cpp
  group Application/generated/texts
    ../../../../generated/texts/src/: LanguageDnk.cpp LanguageGbr.cpp LanguageJpn.cpp LanguageNld.cpp LanguageUkr.cpp Texts.cpp TypedTextDatabase.cpp
  group Application/gui/common
    ../../../../gui/src/common/: Carousel.cpp CollapsibleMenu.cpp DemoPresenter.cpp DotIndicator.cpp FrontendApplication.cpp SwipeContainer.cpp ZoomAnimationBox.cpp
  group Application/gui/custom_controls_screen
    ../../../../gui/src/custom_controls_screen/: CircularProgress.cpp CustomControlsPresenter.cpp CustomControlsView.cpp DatePicker.cpp Gauge.cpp ThreeWayProgressBar.cpp ThreeWayProgressBarCircle.cpp VerticalSlideMenu.cpp WheelSelector.cpp WheelSelectorExtra.cpp
  group Application/gui/game2048_screen
    ../../../../gui/src/game2048_screen/: Game2048Presenter.cpp Game2048View.cpp GameBoard.cpp
  group Application/gui/game2D_screen
    ../../../../gui/src/game2D_screen/: CollectibleItem.cpp Game2DPresenter.cpp Game2DView.cpp ParallaxBackground.cpp
  group Application/gui/graph_screen
    ../../../../gui/src/graph_screen/: AbstractGraph.cpp Graph.cpp GraphBelow.cpp GraphDots.cpp GraphLine.cpp GraphPresenter.cpp GraphView.cpp LegendEntry.cpp PainterColoredBitmap.cpp PainterVerticalAlpha.cpp PieChart.cpp
  group Application/gui/main_menu_screen
    ../../../../gui/src/main_menu_screen/: MainMenuAnimatingButtonsView.cpp MainMenuCarouselView.cpp MainMenuPresenter.cpp MainMenuView.cpp
  group Application/gui/model
    ../../../../gui/src/model/: Model.cpp
  group Application/gui/product_presenter_screen
    ../../../../gui/src/product_presenter_screen/: FeaturePoster.cpp ProductPresenterPresenter.cpp ProductPresenterView.cpp
  group Application/main
    ../../../: main.cpp
  group CubeF4/Board
    ../../../../../../../touchgfx/board/ST/STM32469I-EVAL/source/vendor/Components/ft6x06/: ft6x06.c
    ../../../../../../../touchgfx/board/ST/STM32469I-EVAL/source/vendor/Components/mfxstm32l152/: mfxstm32l152.c
    ../../../../../../../touchgfx/board/ST/STM32469I-EVAL/source/vendor/Components/otm8009a/: otm8009a.c
    ../../../../../../../touchgfx/board/ST/STM32469I-EVAL/source/vendor/STM32469I_EVAL/: stm32469i_eval.c stm32469i_eval_lcd.c stm32469i_eval_qspi.c stm32469i_eval_sdram.c stm32469i_eval_ts.c
  group CubeF4/MCU
    ../../../../../../../touchgfx/framework/source/platform/hal/ST/mcu/stm32f4cube/IAR/: startup_stm32f469xx.s
    ../../../../../../../touchgfx/framework/source/platform/hal/ST/mcu/stm32f4cube/STM32F4xx_HAL_Driver/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_nor.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sdram.c stm32f4xx_hal_sram.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c
    ../../../../../../../touchgfx/framework/source/platform/hal/ST/mcu/stm32f4cube/CMSIS/: system_stm32f4xx.c
  group OS
    ../../../../../../../touchgfx/os/FreeRTOS7.6.0/: OSWrappers.cpp
  group OS/FreeRTOS7.6.0
    ../../../../../../../touchgfx/os/FreeRTOS7.6.0/Source/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../../../../touchgfx/os/FreeRTOS7.6.0/Source/portable/MemMang/: heap_2.c
  group OS/FreeRTOS7.6.0/portable
    ../../../../../../../touchgfx/os/FreeRTOS7.6.0/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group TouchGFXPort/Board
    ../../../../../../../touchgfx/board/ST/STM32469I-EVAL/source/: BoardConfiguration.cpp GPIO.cpp
    ../../../../../../../touchgfx/board/ST/STM32469I-EVAL/source/bsp/: OTM8009TouchController.cpp
  group TouchGFXPort/MCU
    ../../../../../../../touchgfx/framework/source/platform/core/arm/cortex-m/: CortexMMCUInstrumentation.cpp
    ../../../../../../../touchgfx/framework/source/platform/hal/ST/mcu/stm32f4cube/: STM32F4DMA.cpp STM32F4HAL_DSI.cpp

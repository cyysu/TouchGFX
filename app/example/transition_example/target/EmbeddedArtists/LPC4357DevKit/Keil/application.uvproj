# Keil uVision project application.uvproj, settings and files
target Internal Flash and SPIFI (ARM-ADS)
  device: LPC4357 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x1A000000-0x1A07FFFF) IROM2(0x1B000000-0x1B07FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: application
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x1A000000)
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=4
  c define: CORE_M4 NXP
  c include: ..\..\..\..\..\..\..\touchgfx\framework\include;..\..\..\..\..\..\..\touchgfx\os\FreeRTOS7.6.0\Source\include;..\..\..\..\..\..\..\touchgfx\os\FreeRTOS7.6.0\Source\portable\RVDS\ARM_CM4F;..\..\..\..\platform\os;..\..\..\..\gui\include;..\..\..\..\target\include;..\..\..\..\generated\fonts\include;..\..\..\..\generated\images\include;..\..\..\..\generated\texts\include;..\..\..\..\..\..\..\touchgfx\framework\include\platform\hal\nxp\mcu\LPC43xx\vendor;..\..\..\..\..\..\..\touchgfx\framework\include\platform\core\arm\cortex-m\CMSIS;..\..\..\..\..\..\..\touchgfx\framework\source\platform\hal\nxp\lpcspifilib\inc;..\..\..\..\..\..\..\touchgfx\board\EmbeddedArtists\LPC4357DevKit\include\vendor;..\..\..\..\..\..\..\touchgfx\board\EmbeddedArtists\LPC4357DevKit\include
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\Flash.sct
  group Gui
    ../../../../gui/src/down_screen/: DownPresenter.cpp DownView.cpp
    ../../../../gui/src/common/: FrontendApplication.cpp
    ../../../../gui/src/left_screen/: LeftPresenter.cpp LeftView.cpp
    ../../../../gui/src/main_screen/: MainPresenter.cpp MainView.cpp
    ../../../../gui/src/model/: Model.cpp
    ../../../../gui/src/right_screen/: RightPresenter.cpp RightView.cpp
    ../../../../gui/src/up_screen/: UpPresenter.cpp UpView.cpp
  group Generated
    ../../../../generated/fonts/src/: ApplicationFontProvider.cpp
    ../../../../generated/images/src/: bg_transition_center.cpp bg_transition_down.cpp bg_transition_left.cpp bg_transition_right.cpp bg_transition_up.cpp BitmapDatabase.cpp down_btn.cpp down_btn_pressed.cpp left_btn.cpp left_btn_pressed.cpp right_btn.cpp right_btn_pressed.cpp up_btn.cpp up_btn_pressed.cpp
    ../../../../generated/texts/src/: Texts.cpp TypedTextDatabase.cpp
  group Startup
    ../../../../../../../touchgfx/framework/source/platform/hal/nxp/mcu/LPC43xx/Keil/: startup_LPC43xx.s
    ../../../: main.cpp
  group TouchGFXHAL
    ../../../../../../../touchgfx/framework/source/platform/hal/nxp/mcu/LPC43xx/: NXP43XXDMA.cpp NXP43XXHAL.cpp
    ../../../../../../../touchgfx/board/EmbeddedArtists/LPC4357DevKit/source/: BoardConfiguration.cpp GPIO.cpp
    ../../../../../../../touchgfx/board/EmbeddedArtists/LPC4357DevKit/source/bsp/: LEDs_init.c
  group HAL
    ../../../../../../../touchgfx/board/EmbeddedArtists/LPC4357DevKit/source/bsp/: TSC2046TouchController.cpp
    ../../../../../../../touchgfx/board/EmbeddedArtists/LPC4357DevKit/source/vendor/: board.c calibrate.c ea_lcd_board.c fpu_init.c lcd_driver.c lcdb_eeprom.c norflash.c pca9532.c sdram.c system_LPC43xx.c truly_g240320ltsw.c tsc2046_touch.c
    ../../../../../../../touchgfx/framework/source/platform/hal/nxp/lpcspifilib/src/: spifilib_dev_common.c spifilib_fam_mac_2b_stat.c spifilib_fam_spa_2b_pstat.c spifilib_fam_spa_3b_stat.c
    ../../../../../../../touchgfx/framework/source/platform/hal/nxp/mcu/LPC43xx/vendor/: lpc43xx_adc.c lpc43xx_cgu.c lpc43xx_emc.c lpc43xx_gpdma.c lpc43xx_gpio.c lpc43xx_i2c.c lpc43xx_lcd.c lpc43xx_rgu.c lpc43xx_scu.c lpc43xx_ssp.c lpc43xx_timer.c lpc43xx_uart.c
  group OS
    ../../../../../../../touchgfx/os/FreeRTOS7.6.0/: OSWrappers.cpp
    ../../../../../../../touchgfx/os/FreeRTOS7.6.0/Source/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../../../../touchgfx/os/FreeRTOS7.6.0/Source/portable/MemMang/: heap_2.c
    ../../../../../../../touchgfx/os/FreeRTOS7.6.0/Source/portable/RVDS/ARM_CM4F/: port.c
  group Lib
    ../../../../../../../touchgfx/lib/core/cortex_m4f/Keil/: touchgfx_core.lib

# IAR project application.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC4357_M4 NXP LPC4357_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M4; NXP
  ICCARM.CCIncludePath2: ..\..\..\..\platform\os; ..\..\..\..\gui\include; ..\..\..\..\target\include; ..\..\..\..\generated\fonts\include; ..\..\..\..\generated\images\include; ..\..\..\..\generated\texts\include; ..\..\..\..\..\..\..\touchgfx\framework\include; ..\..\..\..\..\..\..\touchgfx\framework\include\platform\core\arm\cortex-m\CMSIS; ..\..\..\..\..\..\..\touchgfx\framework\include\platform\hal\nxp\mcu\LPC43xx\vendor; ..\..\..\..\..\..\..\touchgfx\framework\source\platform\hal\nxp\lpcspifilib\inc; ..\..\..\..\..\..\..\touchgfx\board\EmbeddedArtists\LPC4357DevKit\include\vendor; ..\..\..\..\..\..\..\touchgfx\board\EmbeddedArtists\LPC4357DevKit\include\; ..\..\..\..\..\..\..\touchgfx\os\FreeRTOS7.6.0\Source\include; ..\..\..\..\..\..\..\touchgfx\os\FreeRTOS7.6.0\Source\portable\IAR\ARM_CM4F
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\..\..\..\platform\os\
  OBJCOPY.OOCOutputFile: application.hex
  ILINK.IlinkOutputFile: application.out
  ILINK.IlinkIcfFile: application.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\..\touchgfx\lib\core\cortex_m4f\IAR\touchgfx_core.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/generated/fonts
    ../../../../generated/fonts/src/: ApplicationFontProvider.cpp
  group Application/generated/images
    ../../../../generated/images/src/: bg_transition_center.cpp bg_transition_down.cpp bg_transition_left.cpp bg_transition_right.cpp bg_transition_up.cpp BitmapDatabase.cpp down_btn.cpp down_btn_pressed.cpp left_btn.cpp left_btn_pressed.cpp right_btn.cpp right_btn_pressed.cpp up_btn.cpp up_btn_pressed.cpp
  group Application/generated/texts
    ../../../../generated/texts/src/: Texts.cpp TypedTextDatabase.cpp
  group Application/gui/common
    ../../../../gui/src/common/: FrontendApplication.cpp
  group Application/gui/down_screen
    ../../../../gui/src/down_screen/: DownPresenter.cpp DownView.cpp
  group Application/gui/left_screen
    ../../../../gui/src/left_screen/: LeftPresenter.cpp LeftView.cpp
  group Application/gui/main_screen
    ../../../../gui/src/main_screen/: MainPresenter.cpp MainView.cpp
  group Application/gui/model
    ../../../../gui/src/model/: Model.cpp
  group Application/gui/right_screen
    ../../../../gui/src/right_screen/: RightPresenter.cpp RightView.cpp
  group Application/gui/up_screen
    ../../../../gui/src/up_screen/: UpPresenter.cpp UpView.cpp
  group Application/main
    ../../../: main.cpp
  group Board
    ../../../../../../../touchgfx/board/EmbeddedArtists/LPC4357DevKit/source/: BoardConfiguration.cpp GPIO.cpp
  group Board/LPC4357DevKit/Driver
    ../../../../../../../touchgfx/board/EmbeddedArtists/LPC4357DevKit/source/bsp/: LEDs_init.c TSC2046TouchController.cpp
  group Board/LPC4357DevKit/Vendor
    ../../../../../../../touchgfx/board/EmbeddedArtists/LPC4357DevKit/source/vendor/: board.c calibrate.c ea_lcd_board.c fpu_init.c lcd_driver.c lcdb_eeprom.c norflash.c pca9532.c sdram.c system_LPC43xx.c truly_g240320ltsw.c tsc2046_touch.c
  group MCU
    ../../../../../../../touchgfx/framework/source/platform/hal/nxp/mcu/LPC43xx/: NXP43XXDMA.cpp NXP43XXHAL.cpp
  group MCU/LPC4357
    ../../../../../../../touchgfx/framework/source/platform/hal/nxp/mcu/LPC43xx/vendor/: lpc43xx_adc.c lpc43xx_cgu.c lpc43xx_emc.c lpc43xx_gpdma.c lpc43xx_gpio.c lpc43xx_i2c.c lpc43xx_lcd.c lpc43xx_rgu.c lpc43xx_scu.c lpc43xx_ssp.c lpc43xx_timer.c lpc43xx_uart.c
    ../../../../../../../touchgfx/framework/source/platform/hal/nxp/mcu/LPC43xx/IAR/: startup_LPC43xx.s
  group MCU/spifilib
    ../../../../../../../touchgfx/framework/source/platform/hal/nxp/lpcspifilib/src/: spifilib_dev_common.c spifilib_fam_mac_2b_stat.c spifilib_fam_spa_2b_pstat.c spifilib_fam_spa_3b_stat.c
  group OS
    ../../../../../../../touchgfx/os/FreeRTOS7.6.0/: OSWrappers.cpp
  group OS/FreeRTOS7.6.0
    ../../../../../../../touchgfx/os/FreeRTOS7.6.0/Source/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../../../../touchgfx/os/FreeRTOS7.6.0/Source/portable/MemMang/: heap_2.c
  group OS/FreeRTOS7.6.0/portable
    ../../../../../../../touchgfx/os/FreeRTOS7.6.0/Source/portable/IAR/ARM_CM4F/: port.c portasm.s

# IAR project application.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429NI ST STM32F429NI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: ST; STM32F756xx; USE_FREERTOS_8; USE_OS_SYSTICK; USE_STM32746G_DISCOVERY
  ICCARM.CCIncludePath2: ..\..\..\..\gui\include; ..\..\..\..\target\include; ..\..\..\..\platform\os; ..\..\..\..\generated\fonts\include; ..\..\..\..\generated\images\include; ..\..\..\..\generated\texts\include; ..\..\..\..\..\..\..\touchgfx\framework\include; ..\..\..\..\..\..\..\touchgfx\framework\include\platform\core\arm\cortex-m\CMSIS; ..\..\..\..\..\..\..\touchgfx\framework\include\platform\hal\ST\mcu\stm32f7xx\; ..\..\..\..\..\..\..\touchgfx\framework\include\platform\hal\ST\mcu\stm32f7xx\CMSIS; ..\..\..\..\..\..\..\touchgfx\framework\include\platform\hal\ST\mcu\stm32f7xx\STM32F7xx_HAL_Driver; ..\..\..\..\..\..\..\touchgfx\board\ST\STM32F746G-DISCO\include; ..\..\..\..\..\..\..\touchgfx\board\ST\STM32F746G-DISCO\include\vendor; ..\..\..\..\..\..\..\touchgfx\board\ST\STM32F746G-DISCO\source\vendor\STM32746G-Discovery; ..\..\..\..\..\..\..\touchgfx\os\FreeRTOS8.2.0\Source\include; ..\..\..\..\..\..\..\touchgfx\os\FreeRTOS8.2.0\Source\portable\IAR\ST_CM7
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: USE_FREERTOS_8; USE_OS_SYSTICK
  AARM.AUserIncludes: ..\..\..\..\platform\os; ..\..\..\..\..\framework\touchgfx\platform\core\arm\cortex-m\CMSIS\include; ..\..\..\..\..\framework\touchgfx\platform\hal\ST\board\STM32429I-EVAL1\include; ..\..\..\..\..\framework\touchgfx\platform\hal\ST\board\STM32429I-EVAL1\src; ..\..\..\..\..\framework\touchgfx\platform\hal\ST\mcu\stm32f4x9\inc; ..\..\..\..\..\framework\touchgfx\platform\os\FreeRTOS7.6.0\Source\include; ..\..\..\..\..\framework\touchgfx\platform\os\FreeRTOS7.6.0\Source\portable\IAR\ARM_CM4F
  OBJCOPY.OOCOutputFile: application.hex
  ILINK.IlinkOutputFile: application.out
  ILINK.IlinkIcfFile: application.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\..\touchgfx\lib\core\cortex_m7\IAR\touchgfx_core.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/generated/fonts
    ../../../../generated/fonts/src/: ApplicationFontProvider.cpp
  group Application/generated/images
    ../../../../generated/images/src/: bg_transition_center.cpp bg_transition_down.cpp bg_transition_left.cpp bg_transition_right.cpp bg_transition_up.cpp BitmapDatabase.cpp down_btn.cpp down_btn_pressed.cpp left_btn.cpp left_btn_pressed.cpp right_btn.cpp right_btn_pressed.cpp up_btn.cpp up_btn_pressed.cpp
  group Application/generated/texts
    ../../../../generated/texts/src/: Texts.cpp TypedTextDatabase.cpp
  group Application/gui/common
    ../../../../gui/src/common/: FrontendApplication.cpp
  group Application/gui/down_screen
    ../../../../gui/src/down_screen/: DownPresenter.cpp DownView.cpp
  group Application/gui/left_screen
    ../../../../gui/src/left_screen/: LeftPresenter.cpp LeftView.cpp
  group Application/gui/main_screen
    ../../../../gui/src/main_screen/: MainPresenter.cpp MainView.cpp
  group Application/gui/model
    ../../../../gui/src/model/: Model.cpp
  group Application/gui/right_screen
    ../../../../gui/src/right_screen/: RightPresenter.cpp RightView.cpp
  group Application/gui/up_screen
    ../../../../gui/src/up_screen/: UpPresenter.cpp UpView.cpp
  group Application/main
    ../../../: main.cpp
  group Board/STM32F746G-DISCO
    ../../../../../../../touchgfx/board/ST/STM32F746G-DISCO/source/: BoardConfiguration.cpp GPIO.cpp
  group Board/STM32F746G-DISCO/BSP
    ../../../../../../../touchgfx/board/ST/STM32F746G-DISCO/source/bsp/: STM32F746GTouchController.cpp STM32F7Instrumentation.cpp
  group Board/STM32F746G-DISCO/Vendor
    ../../../../../../../touchgfx/board/ST/STM32F746G-DISCO/source/vendor/Components/ft5336/: ft5336.c
    ../../../../../../../touchgfx/board/ST/STM32F746G-DISCO/source/vendor/STM32746G-Discovery/: stm32746g_discovery.c stm32746g_discovery_lcd.c stm32746g_discovery_qspi.c stm32746g_discovery_sd.c stm32746g_discovery_sdram.c stm32746g_discovery_ts.c
  group MCU
    ../../../../../../../touchgfx/framework/source/platform/hal/ST/mcu/stm32f7xx/: STM32F7DMA.cpp STM32F7HAL.cpp
  group MCU/stm32f7xx
    ../../../../../../../touchgfx/framework/source/platform/hal/ST/mcu/stm32f7xx/IAR/: startup_stm32f746xx.s
    ../../../../../../../touchgfx/framework/source/platform/hal/ST/mcu/stm32f7xx/STM32F7xx_HAL_Driver/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_cec.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_eth.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_irda.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_lptim.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_msp_template.c stm32f7xx_hal_nand.c stm32f7xx_hal_nor.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_wwdg.c stm32f7xx_ll_fmc.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_usb.c
    ../../../../../../../touchgfx/framework/source/platform/hal/ST/mcu/stm32f7xx/CMSIS/: system_stm32f7xx.c
  group OS
    ../../../../../../../touchgfx/os/FreeRTOS8.2.0/: OSWrappers.cpp
  group OS/FreeRTOS8.2.0
    ../../../../../../../touchgfx/os/FreeRTOS8.2.0/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../../../touchgfx/os/FreeRTOS8.2.0/Source/portable/MemMang/: heap_2.c
    ../../../../../../../touchgfx/os/FreeRTOS8.2.0/Source/portable/IAR/ST_CM7/: port.c portasm.s

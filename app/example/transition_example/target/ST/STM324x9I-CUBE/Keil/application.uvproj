# Keil uVision project application.uvproj, settings and files
target Internal flash and NOR (ARM-ADS)
  device: STM32F439NI STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: application
  c flags: Optim=4
  c define: ST STM32F429xx USE_OS_SYSTICK
  c include: ..\..\..\..\gui\include;..\..\..\..\target\include;..\..\..\..\platform\os;..\..\..\..\generated\fonts\include;..\..\..\..\generated\images\include;..\..\..\..\generated\texts\include;..\..\..\..\..\..\..\touchgfx\framework\include;..\..\..\..\..\..\..\touchgfx\framework\include\platform\core\arm\cortex-m\CMSIS;..\..\..\..\..\..\..\touchgfx\framework\include\platform\hal\ST\mcu\stm32f4cube;..\..\..\..\..\..\..\touchgfx\framework\include\platform\hal\ST\mcu\stm32f4cube\STM32F4xx_HAL_Driver;..\..\..\..\..\..\..\touchgfx\framework\include\platform\hal\ST\mcu\stm32f4cube\CMSIS;..\..\..\..\..\..\..\touchgfx\board\ST\STM324x9I-CUBE\include;..\..\..\..\..\..\..\touchgfx\board\ST\STM324x9I-CUBE\include\bsp;..\..\..\..\..\..\..\touchgfx\board\ST\STM324x9I-CUBE\source\vendor\STM324x9I_EVAL;..\..\..\..\..\..\..\touchgfx\os\FreeRTOS7.6.0\Source\include;..\..\..\..\..\..\..\touchgfx\os\FreeRTOS7.6.0\Source\portable\RVDS\ARM_CM4F
  asm include: ..\..\..\..\platform\os
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Flash.sct
  group Startup
    ../../../: main.cpp
    ../../../../../../../touchgfx/framework/source/platform/hal/ST/mcu/stm32f4cube/Keil/: startup_stm32f429xx.s
  group Gui
    ../../../../gui/src/down_screen/: DownPresenter.cpp DownView.cpp
    ../../../../gui/src/common/: FrontendApplication.cpp
    ../../../../gui/src/left_screen/: LeftPresenter.cpp LeftView.cpp
    ../../../../gui/src/main_screen/: MainPresenter.cpp MainView.cpp
    ../../../../gui/src/model/: Model.cpp
    ../../../../gui/src/right_screen/: RightPresenter.cpp RightView.cpp
    ../../../../gui/src/up_screen/: UpPresenter.cpp UpView.cpp
  group Generated
    ../../../../generated/fonts/src/: ApplicationFontProvider.cpp
    ../../../../generated/images/src/: bg_transition_center.cpp bg_transition_down.cpp bg_transition_left.cpp bg_transition_right.cpp bg_transition_up.cpp BitmapDatabase.cpp down_btn.cpp down_btn_pressed.cpp left_btn.cpp left_btn_pressed.cpp right_btn.cpp right_btn_pressed.cpp up_btn.cpp up_btn_pressed.cpp
    ../../../../generated/texts/src/: Texts.cpp TypedTextDatabase.cpp
  group TouchGFXHAL
    ../../../../../../../touchgfx/framework/source/platform/core/arm/cortex-m/: CortexMMCUInstrumentation.cpp
    ../../../../../../../touchgfx/board/ST/STM324x9I-CUBE/source/: BoardConfiguration.cpp GPIO.cpp
    ../../../../../../../touchgfx/board/ST/STM324x9I-CUBE/source/bsp/: STM324x9IButtonController.cpp STM324x9ITouchController.cpp
    ../../../../../../../touchgfx/framework/source/platform/hal/ST/mcu/stm32f4cube/: STM32F4DMA.cpp STM32F4HAL.cpp
  group HAL
    ../../../../../../../touchgfx/board/ST/STM324x9I-CUBE/source/vendor/STM324x9I_EVAL/: stm324x9i_eval.c stm324x9i_eval_lcd.c stm324x9i_eval_nor.c stm324x9i_eval_sdram.c stm324x9i_eval_ts.c stm324x9i_eval_io.c
    ../../../../../../../touchgfx/board/ST/STM324x9I-CUBE/source/vendor/Components/stmpe811/: stmpe811.c
    ../../../../../../../touchgfx/framework/source/platform/hal/ST/mcu/stm32f4cube/STM32F4xx_HAL_Driver/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_nor.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sdram.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_uart.c
    ../../../../../../../touchgfx/framework/source/platform/hal/ST/mcu/stm32f4cube/CMSIS/: system_stm32f4xx.c
    ../../../../../../../touchgfx/board/ST/STM324x9I-CUBE/source/vendor/Components/stmpe1600/: stmpe1600.c
    ../../../../../../../touchgfx/board/ST/STM324x9I-CUBE/source/vendor/Components/ts3510/: ts3510.c
    ../../../../../../../touchgfx/board/ST/STM324x9I-CUBE/source/vendor/Components/exc7200/: exc7200.c
  group OS
    ../../../../../../../touchgfx/os/FreeRTOS7.6.0/Source/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../../../../touchgfx/os/FreeRTOS7.6.0/Source/portable/MemMang/: heap_2.c
    ../../../../../../../touchgfx/os/FreeRTOS7.6.0/: OSWrappers.cpp
    ../../../../../../../touchgfx/os/FreeRTOS7.6.0/Source/portable/RVDS/ARM_CM4F/: port.c
  group Lib
    ../../../../../../../touchgfx/lib/core/cortex_m4f/Keil/: touchgfx_core.lib

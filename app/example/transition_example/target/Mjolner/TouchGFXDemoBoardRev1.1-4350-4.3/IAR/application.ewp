# IAR project application.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC4353_M4 NXP LPC4353_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M4; NXP; DISPLAY_UMSH_8253MD_3T; LPC4350
  ICCARM.CCIncludePath2: ..\..\..\..\gui\include; ..\..\..\..\target\include; ..\..\..\..\platform\os; ..\..\..\..\generated\fonts\include; ..\..\..\..\generated\images\include; ..\..\..\..\generated\texts\include; ..\..\..\..\..\..\..\touchgfx\framework\include\platform\core\arm\cortex-m\CMSIS; ..\..\..\..\..\..\..\touchgfx\framework\include; ..\..\..\..\..\..\..\touchgfx\board\Mjolner\Common\include\bsp; ..\..\..\..\..\..\..\touchgfx\board\Mjolner\Common\include\vendor; ..\..\..\..\..\..\..\touchgfx\board\Mjolner\Common\source\vendor; ..\..\..\..\..\..\..\touchgfx\board\Mjolner\Common\source\vendor\lpc_core\lpc_ip; ..\..\..\..\..\..\..\touchgfx\board\Mjolner\Common\source\vendor\lpc_core\lpc_chip\chip_18xx_43xx; ..\..\..\..\..\..\..\touchgfx\os\FreeRTOS7.6.0\Source\include; ..\..\..\..\..\..\..\touchgfx\os\FreeRTOS7.6.0\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\..\..\touchgfx\framework\include\platform\hal\nxp\mcu\LPC43xx; ..\..\..\..\..\..\..\touchgfx\framework\include\platform\hal\nxp\mcu\LPC43xx\vendor; ..\..\..\..\..\..\..\touchgfx\framework\source\platform\hal\nxp\lpcspifilib\inc; ..\..\..\..\..\..\..\touchgfx\framework\source\platform\hal\nxp\lpcspifilib\src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\..\..\..\platform\os
  OBJCOPY.OOCOutputFile: application.hex
  ILINK.IlinkOutputFile: application.out
  ILINK.IlinkIcfFile: application.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\..\touchgfx\lib\core\cortex_m4f\IAR\touchgfx_core.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/generated/fonts
    ../../../../generated/fonts/src/: ApplicationFontProvider.cpp
  group Application/generated/images
    ../../../../generated/images/src/: bg_transition_center.cpp bg_transition_down.cpp bg_transition_left.cpp bg_transition_right.cpp bg_transition_up.cpp BitmapDatabase.cpp down_btn.cpp down_btn_pressed.cpp left_btn.cpp left_btn_pressed.cpp right_btn.cpp right_btn_pressed.cpp up_btn.cpp up_btn_pressed.cpp
  group Application/generated/texts
    ../../../../generated/texts/src/: Texts.cpp TypedTextDatabase.cpp
  group Application/gui/common
    ../../../../gui/src/common/: FrontendApplication.cpp
  group Application/gui/down_screen
    ../../../../gui/src/down_screen/: DownPresenter.cpp DownView.cpp
  group Application/gui/left_screen
    ../../../../gui/src/left_screen/: LeftPresenter.cpp LeftView.cpp
  group Application/gui/main_screen
    ../../../../gui/src/main_screen/: MainPresenter.cpp MainView.cpp
  group Application/gui/model
    ../../../../gui/src/model/: Model.cpp
  group Application/gui/right_screen
    ../../../../gui/src/right_screen/: RightPresenter.cpp RightView.cpp
  group Application/gui/up_screen
    ../../../../gui/src/up_screen/: UpPresenter.cpp UpView.cpp
  group Application/main
    ../../../: main.cpp
  group Board/TouchGFXDemoBoardRev1.1-4353-4.3
    ../../../../../../../touchgfx/board/Mjolner/TouchGFXDemoBoardRev1.1-4353-4.3/source/: BoardConfiguration.cpp
    ../../../../../../../touchgfx/board/Mjolner/Common/source/: GPIO.cpp
  group Board/TouchGFXDemoBoardRev1.1-4353-4.3/Common/BSP
    ../../../../../../../touchgfx/board/Mjolner/Common/source/bsp/: Buttons.cpp LED.cpp
  group Board/TouchGFXDemoBoardRev1.1-4353-4.3/Common/driver
    ../../../../../../../touchgfx/framework/source/platform/hal/nxp/mcu/LPC43xx/driver/i2c/: I2C_LPC43xx.cpp
    ../../../../../../../touchgfx/board/Mjolner/Common/source/bsp/: KeySampler.cpp
    ../../../../../../../touchgfx/framework/source/platform/driver/touch/: ST1232TouchController.cpp
  group Board/TouchGFXDemoBoardRev1.1-4353-4.3/Common/init
    ../../../../../../../touchgfx/board/Mjolner/Common/source/bsp/: BoardInit.c SystemPinConfig.c
  group Board/TouchGFXDemoBoardRev1.1-4353-4.3/Common/Vendor/lpc_open
    ../../../../../../../touchgfx/board/Mjolner/Common/source/vendor/lpc_core/lpc_chip/chip_18xx_43xx/: clock_18xx_43xx.c emc_18xx_43xx.c lcd_18xx_43xx.c rgu_18xx_43xx.c ssp_18xx_43xx.c
    ../../../../../../../touchgfx/board/Mjolner/Common/source/vendor/lpc_core/lpc_ip/: emc_001.c lcd_001.c ssp_001.c
  group Board/TouchGFXDemoBoardRev1.1-4353-4.3/init
    ../../../../../../../touchgfx/board/Mjolner/TouchGFXDemoBoardRev1.1-4350-4.3/source/bsp/: SystemInit.c SystemInitRAM.c
  group MCU
    ../../../../../../../touchgfx/framework/source/platform/core/arm/cortex-m/: CortexMMCUInstrumentation.cpp
  group MCU/LPC4353
    ../../../../../../../touchgfx/framework/source/platform/hal/nxp/mcu/LPC43xx/: NXP43XXDMA.cpp NXP43XXHAL.cpp
  group MCU/LPC4353/vendor
    ../../../../../../../touchgfx/framework/source/platform/hal/nxp/mcu/LPC43xx/vendor/: lpc43xx_adc.c lpc43xx_cgu.c lpc43xx_emc.c lpc43xx_gpdma.c lpc43xx_gpio.c lpc43xx_i2c.c lpc43xx_lcd.c lpc43xx_rgu.c lpc43xx_scu.c lpc43xx_ssp.c lpc43xx_timer.c lpc43xx_uart.c
    ../../../../../../../touchgfx/framework/source/platform/hal/nxp/mcu/LPC43xx/IAR/: startup_LPC43xx.s
  group MCU/SPIFI
    ../../../../../../../touchgfx/framework/source/platform/hal/nxp/lpcspifilib/src/: spifilib_dev_common.c spifilib_fam_mac_2b_stat.c spifilib_fam_spa_2b_pstat.c spifilib_fam_spa_3b_stat.c
  group OS
    ../../../../../../../touchgfx/os/FreeRTOS7.6.0/: OSWrappers.cpp
  group OS/FreeRTOS7.6.0
    ../../../../../../../touchgfx/os/FreeRTOS7.6.0/Source/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../../../../touchgfx/os/FreeRTOS7.6.0/Source/portable/MemMang/: heap_2.c
  group OS/FreeRTOS7.6.0/portable
    ../../../../../../../touchgfx/os/FreeRTOS7.6.0/Source/portable/IAR/ARM_CM4F/: port.c portasm.s

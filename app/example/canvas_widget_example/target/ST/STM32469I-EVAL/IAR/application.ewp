# IAR project application.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429NI ST STM32F429NI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ST; USE_STDPERIPH_DRIVER; STM32F469xx; USE_STM32469I_EVAL; USE_FLOATING_POINT; USE_OS_SYSTICK; USE_IOEXPANDER
  ICCARM.CCIncludePath2: ..\..\..\..\generated\images\include; ..\..\..\..\generated\fonts\include; ..\..\..\..\generated\texts\include; ..\..\..\..\platform\os; ..\..\..\..\gui\include; ..\..\..\..\target\include; ..\..\..\..\..\..\..\touchgfx\framework\include; ..\..\..\..\..\..\..\touchgfx\framework\include\platform\core\arm\cortex-m\CMSIS; ..\..\..\..\..\..\..\touchgfx\framework\include\platform\hal\ST\mcu\stm32f4cube; ..\..\..\..\..\..\..\touchgfx\framework\include\platform\hal\ST\mcu\stm32f4cube\STM32F4xx_HAL_Driver; ..\..\..\..\..\..\..\touchgfx\framework\include\platform\hal\ST\mcu\stm32f4cube\CMSIS; ..\..\..\..\..\..\..\touchgfx\board\ST\STM32469I-EVAL\include; ..\..\..\..\..\..\..\touchgfx\board\ST\STM32469I-EVAL\include\bsp; ..\..\..\..\..\..\..\touchgfx\board\ST\STM32469I-EVAL\source\vendor\STM32469I_EVAL; ..\..\..\..\..\..\..\touchgfx\os\FreeRTOS7.6.0\Source\include; ..\..\..\..\..\..\..\touchgfx\os\FreeRTOS7.6.0\Source\portable\IAR\ARM_CM4F
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\..\..\..\platform\os; ..\..\..\..\..\framework\touchgfx\platform\core\arm\cortex-m\CMSIS\include; ..\..\..\..\..\framework\touchgfx\platform\hal\ST\board\STM32429I-EVAL1\include; ..\..\..\..\..\framework\touchgfx\platform\hal\ST\board\STM32429I-EVAL1\src; ..\..\..\..\..\framework\touchgfx\platform\hal\ST\mcu\stm32f4x9\inc; ..\..\..\..\..\framework\touchgfx\platform\os\FreeRTOS7.6.0\Source\include; ..\..\..\..\..\framework\touchgfx\platform\os\FreeRTOS7.6.0\Source\portable\IAR\ARM_CM4F
  OBJCOPY.OOCOutputFile: application.hex
  ILINK.IlinkOutputFile: application.out
  ILINK.IlinkIcfFile: application.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\..\touchgfx\lib\core\cortex_m4f\IAR\touchgfx_core.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/generated/fonts
    ../../../../generated/fonts/src/: ApplicationFontProvider.cpp
  group Application/generated/images
    ../../../../generated/images/src/: BitmapDatabase.cpp painter_background.cpp painter_background2.cpp
  group Application/generated/texts
    ../../../../generated/texts/src/: Texts.cpp TypedTextDatabase.cpp
  group Application/gui/common
    ../../../../gui/src/common/: FrontendApplication.cpp
  group Application/gui/main_screen
    ../../../../gui/src/main_screen/: MainPresenter.cpp MainView.cpp
  group Application/gui/model
    ../../../../gui/src/model/: Model.cpp
  group Application/main
    ../../../: main.cpp
  group CubeF4/Board
    ../../../../../../../touchgfx/board/ST/STM32469I-EVAL/source/vendor/Components/ft6x06/: ft6x06.c
    ../../../../../../../touchgfx/board/ST/STM32469I-EVAL/source/vendor/Components/mfxstm32l152/: mfxstm32l152.c
    ../../../../../../../touchgfx/board/ST/STM32469I-EVAL/source/vendor/Components/otm8009a/: otm8009a.c
    ../../../../../../../touchgfx/board/ST/STM32469I-EVAL/source/vendor/STM32469I_EVAL/: stm32469i_eval.c stm32469i_eval_lcd.c stm32469i_eval_qspi.c stm32469i_eval_sdram.c stm32469i_eval_ts.c
  group CubeF4/MCU
    ../../../../../../../touchgfx/framework/source/platform/hal/ST/mcu/stm32f4cube/IAR/: startup_stm32f469xx.s
    ../../../../../../../touchgfx/framework/source/platform/hal/ST/mcu/stm32f4cube/STM32F4xx_HAL_Driver/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_nor.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sdram.c stm32f4xx_hal_sram.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c
    ../../../../../../../touchgfx/framework/source/platform/hal/ST/mcu/stm32f4cube/CMSIS/: system_stm32f4xx.c
  group OS
    ../../../../../../../touchgfx/os/FreeRTOS7.6.0/: OSWrappers.cpp
  group OS/FreeRTOS7.6.0
    ../../../../../../../touchgfx/os/FreeRTOS7.6.0/Source/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../../../../touchgfx/os/FreeRTOS7.6.0/Source/portable/MemMang/: heap_2.c
  group OS/FreeRTOS7.6.0/portable
    ../../../../../../../touchgfx/os/FreeRTOS7.6.0/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group TouchGFXPort/Board
    ../../../../../../../touchgfx/board/ST/STM32469I-EVAL/source/: BoardConfiguration.cpp GPIO.cpp
    ../../../../../../../touchgfx/board/ST/STM32469I-EVAL/source/bsp/: OTM8009TouchController.cpp
  group TouchGFXPort/MCU
    ../../../../../../../touchgfx/framework/source/platform/core/arm/cortex-m/: CortexMMCUInstrumentation.cpp
    ../../../../../../../touchgfx/framework/source/platform/hal/ST/mcu/stm32f4cube/: STM32F4DMA.cpp STM32F4HAL_DSI.cpp

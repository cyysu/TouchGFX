# IAR project application.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC4088 NXP LPC4088
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M4
  ICCARM.CCIncludePath2: ..\..\..\..\platform\os; ..\..\..\..\gui\include; ..\..\..\..\target\include; ..\..\..\..\generated\fonts\include; ..\..\..\..\generated\images\include; ..\..\..\..\generated\texts\include; ..\..\..\..\..\..\..\touchgfx\framework\include; ..\..\..\..\..\..\..\touchgfx\framework\include\platform\core\arm\cortex-m\CMSIS; ..\..\..\..\..\..\..\touchgfx\framework\include\platform\hal\nxp\mcu\LPC40xx\vendor; ..\..\..\..\..\..\..\touchgfx\framework\source\platform\hal\nxp\lpcspifilib\inc; ..\..\..\..\..\..\..\touchgfx\board\EmbeddedArtists\LPC4088DisplayModule\include\vendor; ..\..\..\..\..\..\..\touchgfx\board\EmbeddedArtists\LPC4088DisplayModule\include\; ..\..\..\..\..\..\..\touchgfx\os\FreeRTOS7.6.0\Source\include; ..\..\..\..\..\..\..\touchgfx\os\FreeRTOS7.6.0\Source\portable\IAR\ARM_CM4F
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\..\..\..\platform\os\
  ILINK.IlinkOutputFile: application.out
  ILINK.IlinkIcfFile: application.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\..\touchgfx\lib\core\cortex_m4f\IAR\touchgfx_core.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/generated/fonts
    ../../../../generated/fonts/src/: ApplicationFontProvider.cpp Font_arabtype_24_4bpp.cpp Font_arabtype_26_4bpp.cpp Font_Asap_Regular_14_4bpp.cpp Font_Asap_Regular_18_4bpp.cpp FontGetters.cpp Kerning_arabtype_24_4bpp.cpp Kerning_arabtype_26_4bpp.cpp Kerning_Asap_Regular_14_4bpp.cpp Kerning_Asap_Regular_18_4bpp.cpp Table_arabtype_24_4bpp.cpp Table_arabtype_26_4bpp.cpp Table_Asap_Regular_14_4bpp.cpp Table_Asap_Regular_18_4bpp.cpp
  group Application/generated/images
    ../../../../generated/images/src/: background.cpp BitmapDatabase.cpp btn.cpp btn_pressed.cpp
  group Application/generated/texts
    ../../../../generated/texts/src/: LanguageAr.cpp LanguageGb.cpp Texts.cpp TypedTextDatabase.cpp
  group Application/gui/common
    ../../../../gui/src/common/: FrontendApplication.cpp
  group Application/gui/main_screen
    ../../../../gui/src/main_screen/: MainPresenter.cpp MainView.cpp
  group Application/gui/model
    ../../../../gui/src/model/: Model.cpp
  group Application/main
    ../../../: main.cpp
  group Board
    ../../../../../../../touchgfx/board/EmbeddedArtists/LPC4088DisplayModule/source/vendor/: bios_loader.c board.c board_sysinit.c spifi.c
  group MCU
    ../../../../../../../touchgfx/framework/source/platform/hal/nxp/mcu/LPC40xx/IAR/: startup_lpc40xx.s
  group MCU/lpc
    ../../../../../../../touchgfx/framework/source/platform/hal/nxp/mcu/LPC40xx/vendor/: adc_17xx_40xx.c can_17xx_40xx.c chip_17xx_40xx.c clock_17xx_40xx.c cmp_17xx_40xx.c crc_17xx_40xx.c dac_17xx_40xx.c eeprom_17xx_40xx.c emc_17xx_40xx.c enet_17xx_40xx.c fpu_init.c gpdma_17xx_40xx.c gpio_17xx_40xx.c gpioint_17xx_40xx.c i2c_17xx_40xx.c i2s_17xx_40xx.c iap.c iocon_17xx_40xx.c lcd_17xx_40xx.c pmu_17xx_40xx.c ring_buffer.c ritimer_17xx_40xx.c rtc_17xx_40xx.c sdc_17xx_40xx.c sdmmc_17xx_40xx.c spi_17xx_40xx.c ssp_17xx_40xx.c stopwatch_17xx_40xx.c sysctl_17xx_40xx.c sysinit.c sysinit_17xx_40xx.c timer_17xx_40xx.c uart_17xx_40xx.c wwdt_17xx_40xx.c
  group OS
    ../../../../../../../touchgfx/os/FreeRTOS7.6.0/: OSWrappers.cpp
  group OS/FreeRTOS7.6.0
    ../../../../../../../touchgfx/os/FreeRTOS7.6.0/Source/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../../../../touchgfx/os/FreeRTOS7.6.0/Source/portable/MemMang/: heap_2.c
    ../../../../../../../touchgfx/os/FreeRTOS7.6.0/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group TouchGFXHAL/Board
    ../../../../../../../touchgfx/board/EmbeddedArtists/LPC4088DisplayModule/source/: BoardConfiguration.cpp GPIO.cpp
    ../../../../../../../touchgfx/board/EmbeddedArtists/LPC4088DisplayModule/source/bsp/: DMTouchController.cpp
  group TouchGFXHAL/MCU
    ../../../../../../../touchgfx/framework/source/platform/core/arm/cortex-m/: CortexMMCUInstrumentation.cpp
    ../../../../../../../touchgfx/framework/source/platform/hal/nxp/mcu/LPC40xx/: NXP4088DMA.cpp NXP4088HAL.cpp
